* Functional test stimulus file for 50ns period

* TT process corner
.include "/ldisk/home/etc/tuankiet/Documents/teehw-vlsi-master/tech/lapis200/lib/OpenRAM/lapis20/tech/models/T.inc"
.include "sram_1rw0r0w_16_512_lapis20.sp"

* Global Power Supplies
Vvdd vdd 0 1.8

*Nodes gnd and 0 are the same global ground node in ngspice/hspice/xa. Otherwise, this source may be needed.
*Vgnd gnd 0 0.0

* Instantiation of the SRAM
Xsram_1rw0r0w_16_512_lapis20 din0_0 din0_1 din0_2 din0_3 din0_4 din0_5 din0_6 din0_7 din0_8 din0_9 din0_10 din0_11 din0_12 din0_13 din0_14 din0_15 a0_0 a0_1 a0_2 a0_3 a0_4 a0_5 a0_6 a0_7 a0_8 CSB0 WEB0 clk0 dout0_0 dout0_1 dout0_2 dout0_3 dout0_4 dout0_5 dout0_6 dout0_7 dout0_8 dout0_9 dout0_10 dout0_11 dout0_12 dout0_13 dout0_14 dout0_15 vdd gnd sram_1rw0r0w_16_512_lapis20

* SRAM output loads
CD00 dout0_0  0 0.8364f
CD01 dout0_1  0 0.8364f
CD02 dout0_2  0 0.8364f
CD03 dout0_3  0 0.8364f
CD04 dout0_4  0 0.8364f
CD05 dout0_5  0 0.8364f
CD06 dout0_6  0 0.8364f
CD07 dout0_7  0 0.8364f
CD08 dout0_8  0 0.8364f
CD09 dout0_9  0 0.8364f
CD010 dout0_10  0 0.8364f
CD011 dout0_11  0 0.8364f
CD012 dout0_12  0 0.8364f
CD013 dout0_13  0 0.8364f
CD014 dout0_14  0 0.8364f
CD015 dout0_15  0 0.8364f

* Important signals for debug
* bl:	xsram_1rw0r0w_16_512_lapis20.xbank0.bl_0_0
* br:	xsram_1rw0r0w_16_512_lapis20.xbank0.br_0_0
* s_en:	xsram_1rw0r0w_16_512_lapis20.s_en
* q:	xsram_1rw0r0w_16_512_lapis20.xbank0.xbitcell_array.xbitcell_array.xbit_r0_c0.Q
* qbar:	xsram_1rw0r0w_16_512_lapis20.xbank0.xbitcell_array.xbitcell_array.xbit_r0_c0.Q_bar

* Sequence of operations
*	Idle during cycle 0 (0ns - 50ns)
*	Writing 0001000010010000  to  address 000000110 (from port 0) during cycle 1 (50ns - 100ns)
*	Writing 1101000001000011  to  address 111111000 (from port 0) during cycle 2 (100ns - 150ns)
*	Writing 0000010001000101  to  address 111110111 (from port 0) during cycle 3 (150ns - 200ns)
*	Reading 1101000001000011 from address 111111000 (from port 0) during cycle 4 (200ns - 250ns)
*	Reading 0001000010010000 from address 000000110 (from port 0) during cycle 5 (250ns - 300ns)
*	Writing 0110110111101000  to  address 000000011 (from port 0) during cycle 7 (350ns - 400ns)
*	Reading 0000010001000101 from address 111110111 (from port 0) during cycle 8 (400ns - 450ns)
*	Writing 0011100010001001  to  address 111111000 (from port 0) during cycle 9 (450ns - 500ns)
*	Reading 0001000010010000 from address 000000110 (from port 0) during cycle 12 (600ns - 650ns)
*	Writing 1101001011001100  to  address 000000010 (from port 0) during cycle 13 (650ns - 700ns)
*	Reading 0011100010001001 from address 111111000 (from port 0) during cycle 15 (750ns - 800ns)
*	Reading 0110110111101000 from address 000000011 (from port 0) during cycle 17 (850ns - 900ns)
*	Reading 0000010001000101 from address 111110111 (from port 0) during cycle 18 (900ns - 950ns)
*	Reading 1101001011001100 from address 000000010 (from port 0) during cycle 19 (950ns - 1000ns)
*	Writing 0010111111010001  to  address 111111001 (from port 0) during cycle 21 (1050ns - 1100ns)
*	Writing 0110011010100000  to  address 111111000 (from port 0) during cycle 23 (1150ns - 1200ns)
*	Reading 0010111111010001 from address 111111001 (from port 0) during cycle 25 (1250ns - 1300ns)
*	Reading 0110110111101000 from address 000000011 (from port 0) during cycle 26 (1300ns - 1350ns)
*	Reading 0110011010100000 from address 111111000 (from port 0) during cycle 27 (1350ns - 1400ns)
*	Writing 0111101010101101  to  address 111111001 (from port 0) during cycle 28 (1400ns - 1450ns)
*	Reading 1101001011001100 from address 000000010 (from port 0) during cycle 29 (1450ns - 1500ns)
*	Writing 1101000011110100  to  address 111111011 (from port 0) during cycle 30 (1500ns - 1550ns)
*	Reading 0001000010010000 from address 000000110 (from port 0) during cycle 31 (1550ns - 1600ns)
*	Writing 1111111101111001  to  address 111111001 (from port 0) during cycle 32 (1600ns - 1650ns)
*	Reading 0110011010100000 from address 111111000 (from port 0) during cycle 33 (1650ns - 1700ns)
*	Reading 1111111101111001 from address 111111001 (from port 0) during cycle 34 (1700ns - 1750ns)
*	Reading 0110110111101000 from address 000000011 (from port 0) during cycle 35 (1750ns - 1800ns)
*	Writing 1111000011001000  to  address 000000010 (from port 0) during cycle 36 (1800ns - 1850ns)
*	Writing 0000100011111111  to  address 111110111 (from port 0) during cycle 39 (1950ns - 2000ns)
*	Reading 0110011010100000 from address 111111000 (from port 0) during cycle 40 (2000ns - 2050ns)
*	Reading 1101000011110100 from address 111111011 (from port 0) during cycle 41 (2050ns - 2100ns)
*	Reading 0001000010010000 from address 000000110 (from port 0) during cycle 42 (2100ns - 2150ns)
*	Reading 0110011010100000 from address 111111000 (from port 0) during cycle 43 (2150ns - 2200ns)
*	Reading 0001000010010000 from address 000000110 (from port 0) during cycle 44 (2200ns - 2250ns)
*	Writing 0001001100000111  to  address 000000000 (from port 0) during cycle 45 (2250ns - 2300ns)
*	Reading 1111000011001000 from address 000000010 (from port 0) during cycle 48 (2400ns - 2450ns)
*	Reading 0110011010100000 from address 111111000 (from port 0) during cycle 50 (2500ns - 2550ns)
*	Reading 1111000011001000 from address 000000010 (from port 0) during cycle 51 (2550ns - 2600ns)
*	Reading 0110011010100000 from address 111111000 (from port 0) during cycle 52 (2600ns - 2650ns)
*	Reading 0110110111101000 from address 000000011 (from port 0) during cycle 53 (2650ns - 2700ns)
*	Reading 1101000011110100 from address 111111011 (from port 0) during cycle 55 (2750ns - 2800ns)
*	Writing 0100110100101101  to  address 111111100 (from port 0) during cycle 56 (2800ns - 2850ns)
*	Writing 0010010001100100  to  address 000000111 (from port 0) during cycle 57 (2850ns - 2900ns)
*	Reading 1111111101111001 from address 111111001 (from port 0) during cycle 59 (2950ns - 3000ns)
*	Reading 0001001100000111 from address 000000000 (from port 0) during cycle 61 (3050ns - 3100ns)
*	Writing 0111111100111111  to  address 000000001 (from port 0) during cycle 62 (3100ns - 3150ns)
*	Writing 1110011001111000  to  address 000000111 (from port 0) during cycle 64 (3200ns - 3250ns)
*	Reading 1110011001111000 from address 000000111 (from port 0) during cycle 67 (3350ns - 3400ns)
*	Reading 0001001100000111 from address 000000000 (from port 0) during cycle 68 (3400ns - 3450ns)
*	Writing 1000011110100101  to  address 111110111 (from port 0) during cycle 69 (3450ns - 3500ns)
*	Writing 1110001101001100  to  address 000000001 (from port 0) during cycle 73 (3650ns - 3700ns)
*	Reading 0001001100000111 from address 000000000 (from port 0) during cycle 74 (3700ns - 3750ns)
*	Reading 0100110100101101 from address 111111100 (from port 0) during cycle 75 (3750ns - 3800ns)
*	Reading 1101000011110100 from address 111111011 (from port 0) during cycle 76 (3800ns - 3850ns)
*	Reading 1111111101111001 from address 111111001 (from port 0) during cycle 78 (3900ns - 3950ns)
*	Reading 1111111101111001 from address 111111001 (from port 0) during cycle 79 (3950ns - 4000ns)
*	Reading 1111111101111001 from address 111111001 (from port 0) during cycle 81 (4050ns - 4100ns)
*	Writing 0111000001000100  to  address 111111100 (from port 0) during cycle 82 (4100ns - 4150ns)
*	Reading 1110011001111000 from address 000000111 (from port 0) during cycle 86 (4300ns - 4350ns)
*	Reading 0001000010010000 from address 000000110 (from port 0) during cycle 87 (4350ns - 4400ns)
*	Reading 0111000001000100 from address 111111100 (from port 0) during cycle 88 (4400ns - 4450ns)
*	Writing 1011100101101100  to  address 111111001 (from port 0) during cycle 90 (4500ns - 4550ns)
*	Reading 1111000011001000 from address 000000010 (from port 0) during cycle 91 (4550ns - 4600ns)
*	Reading 1110001101001100 from address 000000001 (from port 0) during cycle 93 (4650ns - 4700ns)
*	Reading 0110011010100000 from address 111111000 (from port 0) during cycle 94 (4700ns - 4750ns)
*	Writing 0100111010010101  to  address 000000001 (from port 0) during cycle 95 (4750ns - 4800ns)
*	Writing 0110010111001001  to  address 000000000 (from port 0) during cycle 96 (4800ns - 4850ns)
*	Writing 1101110100110101  to  address 111111010 (from port 0) during cycle 98 (4900ns - 4950ns)
*	Reading 0110011010100000 from address 111111000 (from port 0) during cycle 99 (4950ns - 5000ns)
*	Reading 0001000010010000 from address 000000110 (from port 0) during cycle 100 (5000ns - 5050ns)
*	Reading 1111000011001000 from address 000000010 (from port 0) during cycle 101 (5050ns - 5100ns)
*	Reading 1000011110100101 from address 111110111 (from port 0) during cycle 103 (5150ns - 5200ns)
*	Reading 1111000011001000 from address 000000010 (from port 0) during cycle 105 (5250ns - 5300ns)
*	Writing 0110010001010100  to  address 000000111 (from port 0) during cycle 106 (5300ns - 5350ns)
*	Reading 0100111010010101 from address 000000001 (from port 0) during cycle 107 (5350ns - 5400ns)
*	Reading 0110011010100000 from address 111111000 (from port 0) during cycle 109 (5450ns - 5500ns)
*	Writing 1000111110100100  to  address 111111110 (from port 0) during cycle 110 (5500ns - 5550ns)
*	Reading 0001000010010000 from address 000000110 (from port 0) during cycle 111 (5550ns - 5600ns)
*	Writing 0001011001111001  to  address 000000111 (from port 0) during cycle 112 (5600ns - 5650ns)
*	Writing 1001101001100101  to  address 111111000 (from port 0) during cycle 115 (5750ns - 5800ns)
*	Reading 1001101001100101 from address 111111000 (from port 0) during cycle 116 (5800ns - 5850ns)
*	Reading 0110110111101000 from address 000000011 (from port 0) during cycle 118 (5900ns - 5950ns)
*	Writing 1010101101010010  to  address 000000100 (from port 0) during cycle 119 (5950ns - 6000ns)
*	Writing 0101000110101011  to  address 111111011 (from port 0) during cycle 120 (6000ns - 6050ns)
*	Reading 1001101001100101 from address 111111000 (from port 0) during cycle 121 (6050ns - 6100ns)
*	Writing 1101101000011000  to  address 111111101 (from port 0) during cycle 122 (6100ns - 6150ns)
*	Reading 0001011001111001 from address 000000111 (from port 0) during cycle 123 (6150ns - 6200ns)
*	Reading 1000111110100100 from address 111111110 (from port 0) during cycle 124 (6200ns - 6250ns)
*	Reading 0101000110101011 from address 111111011 (from port 0) during cycle 125 (6250ns - 6300ns)
*	Reading 0001011001111001 from address 000000111 (from port 0) during cycle 126 (6300ns - 6350ns)
*	Writing 0111011101110101  to  address 000000011 (from port 0) during cycle 127 (6350ns - 6400ns)
*	Reading 0001000010010000 from address 000000110 (from port 0) during cycle 128 (6400ns - 6450ns)
*	Reading 1101101000011000 from address 111111101 (from port 0) during cycle 129 (6450ns - 6500ns)
*	Reading 0110010111001001 from address 000000000 (from port 0) during cycle 130 (6500ns - 6550ns)
*	Reading 1001101001100101 from address 111111000 (from port 0) during cycle 131 (6550ns - 6600ns)
*	Writing 1000110011001111  to  address 111111101 (from port 0) during cycle 132 (6600ns - 6650ns)
*	Reading 1000111110100100 from address 111111110 (from port 0) during cycle 133 (6650ns - 6700ns)
*	Reading 1010101101010010 from address 000000100 (from port 0) during cycle 134 (6700ns - 6750ns)
*	Reading 0110010111001001 from address 000000000 (from port 0) during cycle 135 (6750ns - 6800ns)
*	Reading 0100111010010101 from address 000000001 (from port 0) during cycle 138 (6900ns - 6950ns)
*	Reading 1011100101101100 from address 111111001 (from port 0) during cycle 140 (7000ns - 7050ns)
*	Reading 1000110011001111 from address 111111101 (from port 0) during cycle 143 (7150ns - 7200ns)
*	Writing 1000000000110101  to  address 000000000 (from port 0) during cycle 144 (7200ns - 7250ns)
*	Reading 0111011101110101 from address 000000011 (from port 0) during cycle 145 (7250ns - 7300ns)
*	Reading 1000111110100100 from address 111111110 (from port 0) during cycle 147 (7350ns - 7400ns)
*	Reading 1000000000110101 from address 000000000 (from port 0) during cycle 148 (7400ns - 7450ns)
*	Writing 1000111100111000  to  address 111111000 (from port 0) during cycle 149 (7450ns - 7500ns)
*	Writing 1110001011010011  to  address 000000000 (from port 0) during cycle 150 (7500ns - 7550ns)
*	Reading 1000111110100100 from address 111111110 (from port 0) during cycle 151 (7550ns - 7600ns)
*	Reading 0001011001111001 from address 000000111 (from port 0) during cycle 152 (7600ns - 7650ns)
*	Reading 1000011110100101 from address 111110111 (from port 0) during cycle 153 (7650ns - 7700ns)
*	Writing 1000011001111010  to  address 111111101 (from port 0) during cycle 154 (7700ns - 7750ns)
*	Reading 0111011101110101 from address 000000011 (from port 0) during cycle 155 (7750ns - 7800ns)
*	Writing 0111001010101011  to  address 000000001 (from port 0) during cycle 156 (7800ns - 7850ns)
*	Writing 0001100000011100  to  address 111111110 (from port 0) during cycle 157 (7850ns - 7900ns)
*	Reading 0001000010010000 from address 000000110 (from port 0) during cycle 158 (7900ns - 7950ns)
*	Writing 0000010100111010  to  address 111111100 (from port 0) during cycle 159 (7950ns - 8000ns)
*	Reading 0001011001111001 from address 000000111 (from port 0) during cycle 160 (8000ns - 8050ns)
*	Writing 0001000110110000  to  address 111111010 (from port 0) during cycle 161 (8050ns - 8100ns)
*	Reading 0001011001111001 from address 000000111 (from port 0) during cycle 162 (8100ns - 8150ns)
*	Writing 1001100000100100  to  address 111111110 (from port 0) during cycle 163 (8150ns - 8200ns)
*	Reading 1011100101101100 from address 111111001 (from port 0) during cycle 164 (8200ns - 8250ns)
*	Reading 1000011001111010 from address 111111101 (from port 0) during cycle 165 (8250ns - 8300ns)
*	Reading 0001011001111001 from address 000000111 (from port 0) during cycle 166 (8300ns - 8350ns)
*	Reading 0001011001111001 from address 000000111 (from port 0) during cycle 167 (8350ns - 8400ns)
*	Writing 1010101001010010  to  address 000000110 (from port 0) during cycle 169 (8450ns - 8500ns)
*	Reading 1010101001010010 from address 000000110 (from port 0) during cycle 170 (8500ns - 8550ns)
*	Reading 0111011101110101 from address 000000011 (from port 0) during cycle 171 (8550ns - 8600ns)
*	Reading 0101000110101011 from address 111111011 (from port 0) during cycle 173 (8650ns - 8700ns)
*	Reading 0111001010101011 from address 000000001 (from port 0) during cycle 174 (8700ns - 8750ns)
*	Writing 1010000000000111  to  address 000000010 (from port 0) during cycle 175 (8750ns - 8800ns)
*	Reading 0101000110101011 from address 111111011 (from port 0) during cycle 176 (8800ns - 8850ns)
*	Reading 0111001010101011 from address 000000001 (from port 0) during cycle 177 (8850ns - 8900ns)
*	Writing 0011110100101001  to  address 111111001 (from port 0) during cycle 178 (8900ns - 8950ns)
*	Reading 1000111100111000 from address 111111000 (from port 0) during cycle 179 (8950ns - 9000ns)
*	Writing 1110001111011011  to  address 000000101 (from port 0) during cycle 180 (9000ns - 9050ns)
*	Writing 1010010100000001  to  address 000000111 (from port 0) during cycle 181 (9050ns - 9100ns)
*	Reading 0101000110101011 from address 111111011 (from port 0) during cycle 183 (9150ns - 9200ns)
*	Reading 1010101001010010 from address 000000110 (from port 0) during cycle 184 (9200ns - 9250ns)
*	Reading 1010000000000111 from address 000000010 (from port 0) during cycle 185 (9250ns - 9300ns)
*	Reading 0101000110101011 from address 111111011 (from port 0) during cycle 186 (9300ns - 9350ns)
*	Writing 0100100010000101  to  address 111111011 (from port 0) during cycle 188 (9400ns - 9450ns)
*	Reading 1001100000100100 from address 111111110 (from port 0) during cycle 190 (9500ns - 9550ns)
*	Reading 1000011110100101 from address 111110111 (from port 0) during cycle 191 (9550ns - 9600ns)
*	Writing 0101111101011011  to  address 111111000 (from port 0) during cycle 192 (9600ns - 9650ns)
*	Reading 1000011110100101 from address 111110111 (from port 0) during cycle 194 (9700ns - 9750ns)
*	Reading 0001000110110000 from address 111111010 (from port 0) during cycle 195 (9750ns - 9800ns)
*	Reading 0100100010000101 from address 111111011 (from port 0) during cycle 196 (9800ns - 9850ns)
*	Reading 1010101001010010 from address 000000110 (from port 0) during cycle 197 (9850ns - 9900ns)
*	Reading 1110001111011011 from address 000000101 (from port 0) during cycle 198 (9900ns - 9950ns)
*	Reading 1010101001010010 from address 000000110 (from port 0) during cycle 199 (9950ns - 10000ns)
*	Writing 0010111111100101  to  address 111111101 (from port 0) during cycle 200 (10000ns - 10050ns)
*	Reading 0111001010101011 from address 000000001 (from port 0) during cycle 201 (10050ns - 10100ns)
*	Reading 0010111111100101 from address 111111101 (from port 0) during cycle 202 (10100ns - 10150ns)
*	Writing 0101001100000101  to  address 111111100 (from port 0) during cycle 203 (10150ns - 10200ns)
*	Idle during cycle 205 (10250ns - 10300ns)

* Generation of data and address signals
* (time, data): [(0, 0), (50, 0), (100, 1), (150, 1), (200, 1), (250, 1), (300, 1), (350, 0), (400, 0), (450, 1), (500, 1), (550, 1), (600, 1), (650, 0), (700, 0), (750, 0), (800, 0), (850, 0), (900, 0), (950, 0), (1000, 0), (1050, 1), (1100, 1), (1150, 0), (1200, 0), (1250, 0), (1300, 0), (1350, 0), (1400, 1), (1450, 1), (1500, 0), (1550, 0), (1600, 1), (1650, 1), (1700, 1), (1750, 1), (1800, 0), (1850, 0), (1900, 0), (1950, 1), (2000, 1), (2050, 1), (2100, 1), (2150, 1), (2200, 1), (2250, 1), (2300, 1), (2350, 1), (2400, 1), (2450, 1), (2500, 1), (2550, 1), (2600, 1), (2650, 1), (2700, 1), (2750, 1), (2800, 1), (2850, 0), (2900, 0), (2950, 0), (3000, 0), (3050, 0), (3100, 1), (3150, 1), (3200, 0), (3250, 0), (3300, 0), (3350, 0), (3400, 0), (3450, 1), (3500, 1), (3550, 1), (3600, 1), (3650, 0), (3700, 0), (3750, 0), (3800, 0), (3850, 0), (3900, 0), (3950, 0), (4000, 0), (4050, 0), (4100, 0), (4150, 0), (4200, 0), (4250, 0), (4300, 0), (4350, 0), (4400, 0), (4450, 0), (4500, 0), (4550, 0), (4600, 0), (4650, 0), (4700, 0), (4750, 1), (4800, 1), (4850, 1), (4900, 1), (4950, 1), (5000, 1), (5050, 1), (5100, 1), (5150, 1), (5200, 1), (5250, 1), (5300, 0), (5350, 0), (5400, 0), (5450, 0), (5500, 0), (5550, 0), (5600, 1), (5650, 1), (5700, 1), (5750, 1), (5800, 1), (5850, 1), (5900, 1), (5950, 0), (6000, 1), (6050, 1), (6100, 0), (6150, 0), (6200, 0), (6250, 0), (6300, 0), (6350, 1), (6400, 1), (6450, 1), (6500, 1), (6550, 1), (6600, 1), (6650, 1), (6700, 1), (6750, 1), (6800, 1), (6850, 1), (6900, 1), (6950, 1), (7000, 1), (7050, 1), (7100, 1), (7150, 1), (7200, 1), (7250, 1), (7300, 1), (7350, 1), (7400, 1), (7450, 0), (7500, 1), (7550, 1), (7600, 1), (7650, 1), (7700, 0), (7750, 0), (7800, 1), (7850, 0), (7900, 0), (7950, 0), (8000, 0), (8050, 0), (8100, 0), (8150, 0), (8200, 0), (8250, 0), (8300, 0), (8350, 0), (8400, 0), (8450, 0), (8500, 0), (8550, 0), (8600, 0), (8650, 0), (8700, 0), (8750, 1), (8800, 1), (8850, 1), (8900, 1), (8950, 1), (9000, 1), (9050, 1), (9100, 1), (9150, 1), (9200, 1), (9250, 1), (9300, 1), (9350, 1), (9400, 1), (9450, 1), (9500, 1), (9550, 1), (9600, 1), (9650, 1), (9700, 1), (9750, 1), (9800, 1), (9850, 1), (9900, 1), (9950, 1), (10000, 1), (10050, 1), (10100, 1), (10150, 1), (10200, 1), (10250, 1)]
Vdin0_0  din0_0  0 PWL (0n 0.0v 47.49n 0.0v 47.51n 0.0v 97.49n 0.0v 97.51n 1.8v 147.49n 1.8v 147.51n 1.8v 197.49n 1.8v 197.51n 1.8v 247.49n 1.8v 247.51n 1.8v 297.49n 1.8v 297.51n 1.8v 347.49n 1.8v 347.51n 0.0v 397.49n 0.0v 397.51n 0.0v 447.49n 0.0v 447.51n 1.8v 497.49n 1.8v 497.51n 1.8v 547.49n 1.8v 547.51n 1.8v 597.49n 1.8v 597.51n 1.8v 647.49n 1.8v 647.51n 0.0v 697.49n 0.0v 697.51n 0.0v 747.49n 0.0v 747.51n 0.0v 797.49n 0.0v 797.51n 0.0v 847.49n 0.0v 847.51n 0.0v 897.49n 0.0v 897.51n 0.0v 947.49n 0.0v 947.51n 0.0v 997.49n 0.0v 997.51n 0.0v 1047.49n 0.0v 1047.51n 1.8v 1097.49n 1.8v 1097.51n 1.8v 1147.49n 1.8v 1147.51n 0.0v 1197.49n 0.0v 1197.51n 0.0v 1247.49n 0.0v 1247.51n 0.0v 1297.49n 0.0v 1297.51n 0.0v 1347.49n 0.0v 1347.51n 0.0v 1397.49n 0.0v 1397.51n 1.8v 1447.49n 1.8v 1447.51n 1.8v 1497.49n 1.8v 1497.51n 0.0v 1547.49n 0.0v 1547.51n 0.0v 1597.49n 0.0v 1597.51n 1.8v 1647.49n 1.8v 1647.51n 1.8v 1697.49n 1.8v 1697.51n 1.8v 1747.49n 1.8v 1747.51n 1.8v 1797.49n 1.8v 1797.51n 0.0v 1847.49n 0.0v 1847.51n 0.0v 1897.49n 0.0v 1897.51n 0.0v 1947.49n 0.0v 1947.51n 1.8v 1997.49n 1.8v 1997.51n 1.8v 2047.49n 1.8v 2047.51n 1.8v 2097.49n 1.8v 2097.51n 1.8v 2147.49n 1.8v 2147.51n 1.8v 2197.49n 1.8v 2197.51n 1.8v 2247.49n 1.8v 2247.51n 1.8v 2297.49n 1.8v 2297.51n 1.8v 2347.49n 1.8v 2347.51n 1.8v 2397.49n 1.8v 2397.51n 1.8v 2447.49n 1.8v 2447.51n 1.8v 2497.49n 1.8v 2497.51n 1.8v 2547.49n 1.8v 2547.51n 1.8v 2597.49n 1.8v 2597.51n 1.8v 2647.49n 1.8v 2647.51n 1.8v 2697.49n 1.8v 2697.51n 1.8v 2747.49n 1.8v 2747.51n 1.8v 2797.49n 1.8v 2797.51n 1.8v 2847.49n 1.8v 2847.51n 0.0v 2897.49n 0.0v 2897.51n 0.0v 2947.49n 0.0v 2947.51n 0.0v 2997.49n 0.0v 2997.51n 0.0v 3047.49n 0.0v 3047.51n 0.0v 3097.49n 0.0v 3097.51n 1.8v 3147.49n 1.8v 3147.51n 1.8v 3197.49n 1.8v 3197.51n 0.0v 3247.49n 0.0v 3247.51n 0.0v 3297.49n 0.0v 3297.51n 0.0v 3347.49n 0.0v 3347.51n 0.0v 3397.49n 0.0v 3397.51n 0.0v 3447.49n 0.0v 3447.51n 1.8v 3497.49n 1.8v 3497.51n 1.8v 3547.49n 1.8v 3547.51n 1.8v 3597.49n 1.8v 3597.51n 1.8v 3647.49n 1.8v 3647.51n 0.0v 3697.49n 0.0v 3697.51n 0.0v 3747.49n 0.0v 3747.51n 0.0v 3797.49n 0.0v 3797.51n 0.0v 3847.49n 0.0v 3847.51n 0.0v 3897.49n 0.0v 3897.51n 0.0v 3947.49n 0.0v 3947.51n 0.0v 3997.49n 0.0v 3997.51n 0.0v 4047.49n 0.0v 4047.51n 0.0v 4097.49n 0.0v 4097.51n 0.0v 4147.49n 0.0v 4147.51n 0.0v 4197.49n 0.0v 4197.51n 0.0v 4247.49n 0.0v 4247.51n 0.0v 4297.49n 0.0v 4297.51n 0.0v 4347.49n 0.0v 4347.51n 0.0v 4397.49n 0.0v 4397.51n 0.0v 4447.49n 0.0v 4447.51n 0.0v 4497.49n 0.0v 4497.51n 0.0v 4547.49n 0.0v 4547.51n 0.0v 4597.49n 0.0v 4597.51n 0.0v 4647.49n 0.0v 4647.51n 0.0v 4697.49n 0.0v 4697.51n 0.0v 4747.49n 0.0v 4747.51n 1.8v 4797.49n 1.8v 4797.51n 1.8v 4847.49n 1.8v 4847.51n 1.8v 4897.49n 1.8v 4897.51n 1.8v 4947.49n 1.8v 4947.51n 1.8v 4997.49n 1.8v 4997.51n 1.8v 5047.49n 1.8v 5047.51n 1.8v 5097.49n 1.8v 5097.51n 1.8v 5147.49n 1.8v 5147.51n 1.8v 5197.49n 1.8v 5197.51n 1.8v 5247.49n 1.8v 5247.51n 1.8v 5297.49n 1.8v 5297.51n 0.0v 5347.49n 0.0v 5347.51n 0.0v 5397.49n 0.0v 5397.51n 0.0v 5447.49n 0.0v 5447.51n 0.0v 5497.49n 0.0v 5497.51n 0.0v 5547.49n 0.0v 5547.51n 0.0v 5597.49n 0.0v 5597.51n 1.8v 5647.49n 1.8v 5647.51n 1.8v 5697.49n 1.8v 5697.51n 1.8v 5747.49n 1.8v 5747.51n 1.8v 5797.49n 1.8v 5797.51n 1.8v 5847.49n 1.8v 5847.51n 1.8v 5897.49n 1.8v 5897.51n 1.8v 5947.49n 1.8v 5947.51n 0.0v 5997.49n 0.0v 5997.51n 1.8v 6047.49n 1.8v 6047.51n 1.8v 6097.49n 1.8v 6097.51n 0.0v 6147.49n 0.0v 6147.51n 0.0v 6197.49n 0.0v 6197.51n 0.0v 6247.49n 0.0v 6247.51n 0.0v 6297.49n 0.0v 6297.51n 0.0v 6347.49n 0.0v 6347.51n 1.8v 6397.49n 1.8v 6397.51n 1.8v 6447.49n 1.8v 6447.51n 1.8v 6497.49n 1.8v 6497.51n 1.8v 6547.49n 1.8v 6547.51n 1.8v 6597.49n 1.8v 6597.51n 1.8v 6647.49n 1.8v 6647.51n 1.8v 6697.49n 1.8v 6697.51n 1.8v 6747.49n 1.8v 6747.51n 1.8v 6797.49n 1.8v 6797.51n 1.8v 6847.49n 1.8v 6847.51n 1.8v 6897.49n 1.8v 6897.51n 1.8v 6947.49n 1.8v 6947.51n 1.8v 6997.49n 1.8v 6997.51n 1.8v 7047.49n 1.8v 7047.51n 1.8v 7097.49n 1.8v 7097.51n 1.8v 7147.49n 1.8v 7147.51n 1.8v 7197.49n 1.8v 7197.51n 1.8v 7247.49n 1.8v 7247.51n 1.8v 7297.49n 1.8v 7297.51n 1.8v 7347.49n 1.8v 7347.51n 1.8v 7397.49n 1.8v 7397.51n 1.8v 7447.49n 1.8v 7447.51n 0.0v 7497.49n 0.0v 7497.51n 1.8v 7547.49n 1.8v 7547.51n 1.8v 7597.49n 1.8v 7597.51n 1.8v 7647.49n 1.8v 7647.51n 1.8v 7697.49n 1.8v 7697.51n 0.0v 7747.49n 0.0v 7747.51n 0.0v 7797.49n 0.0v 7797.51n 1.8v 7847.49n 1.8v 7847.51n 0.0v 7897.49n 0.0v 7897.51n 0.0v 7947.49n 0.0v 7947.51n 0.0v 7997.49n 0.0v 7997.51n 0.0v 8047.49n 0.0v 8047.51n 0.0v 8097.49n 0.0v 8097.51n 0.0v 8147.49n 0.0v 8147.51n 0.0v 8197.49n 0.0v 8197.51n 0.0v 8247.49n 0.0v 8247.51n 0.0v 8297.49n 0.0v 8297.51n 0.0v 8347.49n 0.0v 8347.51n 0.0v 8397.49n 0.0v 8397.51n 0.0v 8447.49n 0.0v 8447.51n 0.0v 8497.49n 0.0v 8497.51n 0.0v 8547.49n 0.0v 8547.51n 0.0v 8597.49n 0.0v 8597.51n 0.0v 8647.49n 0.0v 8647.51n 0.0v 8697.49n 0.0v 8697.51n 0.0v 8747.49n 0.0v 8747.51n 1.8v 8797.49n 1.8v 8797.51n 1.8v 8847.49n 1.8v 8847.51n 1.8v 8897.49n 1.8v 8897.51n 1.8v 8947.49n 1.8v 8947.51n 1.8v 8997.49n 1.8v 8997.51n 1.8v 9047.49n 1.8v 9047.51n 1.8v 9097.49n 1.8v 9097.51n 1.8v 9147.49n 1.8v 9147.51n 1.8v 9197.49n 1.8v 9197.51n 1.8v 9247.49n 1.8v 9247.51n 1.8v 9297.49n 1.8v 9297.51n 1.8v 9347.49n 1.8v 9347.51n 1.8v 9397.49n 1.8v 9397.51n 1.8v 9447.49n 1.8v 9447.51n 1.8v 9497.49n 1.8v 9497.51n 1.8v 9547.49n 1.8v 9547.51n 1.8v 9597.49n 1.8v 9597.51n 1.8v 9647.49n 1.8v 9647.51n 1.8v 9697.49n 1.8v 9697.51n 1.8v 9747.49n 1.8v 9747.51n 1.8v 9797.49n 1.8v 9797.51n 1.8v 9847.49n 1.8v 9847.51n 1.8v 9897.49n 1.8v 9897.51n 1.8v 9947.49n 1.8v 9947.51n 1.8v 9997.49n 1.8v 9997.51n 1.8v 10047.49n 1.8v 10047.51n 1.8v 10097.49n 1.8v 10097.51n 1.8v 10147.49n 1.8v 10147.51n 1.8v 10197.49n 1.8v 10197.51n 1.8v 10247.49n 1.8v 10247.51n 1.8v )
* (time, data): [(0, 0), (50, 0), (100, 1), (150, 0), (200, 0), (250, 0), (300, 0), (350, 0), (400, 0), (450, 0), (500, 0), (550, 0), (600, 0), (650, 0), (700, 0), (750, 0), (800, 0), (850, 0), (900, 0), (950, 0), (1000, 0), (1050, 0), (1100, 0), (1150, 0), (1200, 0), (1250, 0), (1300, 0), (1350, 0), (1400, 0), (1450, 0), (1500, 0), (1550, 0), (1600, 0), (1650, 0), (1700, 0), (1750, 0), (1800, 0), (1850, 0), (1900, 0), (1950, 1), (2000, 1), (2050, 1), (2100, 1), (2150, 1), (2200, 1), (2250, 1), (2300, 1), (2350, 1), (2400, 1), (2450, 1), (2500, 1), (2550, 1), (2600, 1), (2650, 1), (2700, 1), (2750, 1), (2800, 0), (2850, 0), (2900, 0), (2950, 0), (3000, 0), (3050, 0), (3100, 1), (3150, 1), (3200, 0), (3250, 0), (3300, 0), (3350, 0), (3400, 0), (3450, 0), (3500, 0), (3550, 0), (3600, 0), (3650, 0), (3700, 0), (3750, 0), (3800, 0), (3850, 0), (3900, 0), (3950, 0), (4000, 0), (4050, 0), (4100, 0), (4150, 0), (4200, 0), (4250, 0), (4300, 0), (4350, 0), (4400, 0), (4450, 0), (4500, 0), (4550, 0), (4600, 0), (4650, 0), (4700, 0), (4750, 0), (4800, 0), (4850, 0), (4900, 0), (4950, 0), (5000, 0), (5050, 0), (5100, 0), (5150, 0), (5200, 0), (5250, 0), (5300, 0), (5350, 0), (5400, 0), (5450, 0), (5500, 0), (5550, 0), (5600, 0), (5650, 0), (5700, 0), (5750, 0), (5800, 0), (5850, 0), (5900, 0), (5950, 1), (6000, 1), (6050, 1), (6100, 0), (6150, 0), (6200, 0), (6250, 0), (6300, 0), (6350, 0), (6400, 0), (6450, 0), (6500, 0), (6550, 0), (6600, 1), (6650, 1), (6700, 1), (6750, 1), (6800, 1), (6850, 1), (6900, 1), (6950, 1), (7000, 1), (7050, 1), (7100, 1), (7150, 1), (7200, 0), (7250, 0), (7300, 0), (7350, 0), (7400, 0), (7450, 0), (7500, 1), (7550, 1), (7600, 1), (7650, 1), (7700, 1), (7750, 1), (7800, 1), (7850, 0), (7900, 0), (7950, 1), (8000, 1), (8050, 0), (8100, 0), (8150, 0), (8200, 0), (8250, 0), (8300, 0), (8350, 0), (8400, 0), (8450, 1), (8500, 1), (8550, 1), (8600, 1), (8650, 1), (8700, 1), (8750, 1), (8800, 1), (8850, 1), (8900, 0), (8950, 0), (9000, 1), (9050, 0), (9100, 0), (9150, 0), (9200, 0), (9250, 0), (9300, 0), (9350, 0), (9400, 0), (9450, 0), (9500, 0), (9550, 0), (9600, 1), (9650, 1), (9700, 1), (9750, 1), (9800, 1), (9850, 1), (9900, 1), (9950, 1), (10000, 0), (10050, 0), (10100, 0), (10150, 0), (10200, 0), (10250, 0)]
Vdin0_1  din0_1  0 PWL (0n 0.0v 47.49n 0.0v 47.51n 0.0v 97.49n 0.0v 97.51n 1.8v 147.49n 1.8v 147.51n 0.0v 197.49n 0.0v 197.51n 0.0v 247.49n 0.0v 247.51n 0.0v 297.49n 0.0v 297.51n 0.0v 347.49n 0.0v 347.51n 0.0v 397.49n 0.0v 397.51n 0.0v 447.49n 0.0v 447.51n 0.0v 497.49n 0.0v 497.51n 0.0v 547.49n 0.0v 547.51n 0.0v 597.49n 0.0v 597.51n 0.0v 647.49n 0.0v 647.51n 0.0v 697.49n 0.0v 697.51n 0.0v 747.49n 0.0v 747.51n 0.0v 797.49n 0.0v 797.51n 0.0v 847.49n 0.0v 847.51n 0.0v 897.49n 0.0v 897.51n 0.0v 947.49n 0.0v 947.51n 0.0v 997.49n 0.0v 997.51n 0.0v 1047.49n 0.0v 1047.51n 0.0v 1097.49n 0.0v 1097.51n 0.0v 1147.49n 0.0v 1147.51n 0.0v 1197.49n 0.0v 1197.51n 0.0v 1247.49n 0.0v 1247.51n 0.0v 1297.49n 0.0v 1297.51n 0.0v 1347.49n 0.0v 1347.51n 0.0v 1397.49n 0.0v 1397.51n 0.0v 1447.49n 0.0v 1447.51n 0.0v 1497.49n 0.0v 1497.51n 0.0v 1547.49n 0.0v 1547.51n 0.0v 1597.49n 0.0v 1597.51n 0.0v 1647.49n 0.0v 1647.51n 0.0v 1697.49n 0.0v 1697.51n 0.0v 1747.49n 0.0v 1747.51n 0.0v 1797.49n 0.0v 1797.51n 0.0v 1847.49n 0.0v 1847.51n 0.0v 1897.49n 0.0v 1897.51n 0.0v 1947.49n 0.0v 1947.51n 1.8v 1997.49n 1.8v 1997.51n 1.8v 2047.49n 1.8v 2047.51n 1.8v 2097.49n 1.8v 2097.51n 1.8v 2147.49n 1.8v 2147.51n 1.8v 2197.49n 1.8v 2197.51n 1.8v 2247.49n 1.8v 2247.51n 1.8v 2297.49n 1.8v 2297.51n 1.8v 2347.49n 1.8v 2347.51n 1.8v 2397.49n 1.8v 2397.51n 1.8v 2447.49n 1.8v 2447.51n 1.8v 2497.49n 1.8v 2497.51n 1.8v 2547.49n 1.8v 2547.51n 1.8v 2597.49n 1.8v 2597.51n 1.8v 2647.49n 1.8v 2647.51n 1.8v 2697.49n 1.8v 2697.51n 1.8v 2747.49n 1.8v 2747.51n 1.8v 2797.49n 1.8v 2797.51n 0.0v 2847.49n 0.0v 2847.51n 0.0v 2897.49n 0.0v 2897.51n 0.0v 2947.49n 0.0v 2947.51n 0.0v 2997.49n 0.0v 2997.51n 0.0v 3047.49n 0.0v 3047.51n 0.0v 3097.49n 0.0v 3097.51n 1.8v 3147.49n 1.8v 3147.51n 1.8v 3197.49n 1.8v 3197.51n 0.0v 3247.49n 0.0v 3247.51n 0.0v 3297.49n 0.0v 3297.51n 0.0v 3347.49n 0.0v 3347.51n 0.0v 3397.49n 0.0v 3397.51n 0.0v 3447.49n 0.0v 3447.51n 0.0v 3497.49n 0.0v 3497.51n 0.0v 3547.49n 0.0v 3547.51n 0.0v 3597.49n 0.0v 3597.51n 0.0v 3647.49n 0.0v 3647.51n 0.0v 3697.49n 0.0v 3697.51n 0.0v 3747.49n 0.0v 3747.51n 0.0v 3797.49n 0.0v 3797.51n 0.0v 3847.49n 0.0v 3847.51n 0.0v 3897.49n 0.0v 3897.51n 0.0v 3947.49n 0.0v 3947.51n 0.0v 3997.49n 0.0v 3997.51n 0.0v 4047.49n 0.0v 4047.51n 0.0v 4097.49n 0.0v 4097.51n 0.0v 4147.49n 0.0v 4147.51n 0.0v 4197.49n 0.0v 4197.51n 0.0v 4247.49n 0.0v 4247.51n 0.0v 4297.49n 0.0v 4297.51n 0.0v 4347.49n 0.0v 4347.51n 0.0v 4397.49n 0.0v 4397.51n 0.0v 4447.49n 0.0v 4447.51n 0.0v 4497.49n 0.0v 4497.51n 0.0v 4547.49n 0.0v 4547.51n 0.0v 4597.49n 0.0v 4597.51n 0.0v 4647.49n 0.0v 4647.51n 0.0v 4697.49n 0.0v 4697.51n 0.0v 4747.49n 0.0v 4747.51n 0.0v 4797.49n 0.0v 4797.51n 0.0v 4847.49n 0.0v 4847.51n 0.0v 4897.49n 0.0v 4897.51n 0.0v 4947.49n 0.0v 4947.51n 0.0v 4997.49n 0.0v 4997.51n 0.0v 5047.49n 0.0v 5047.51n 0.0v 5097.49n 0.0v 5097.51n 0.0v 5147.49n 0.0v 5147.51n 0.0v 5197.49n 0.0v 5197.51n 0.0v 5247.49n 0.0v 5247.51n 0.0v 5297.49n 0.0v 5297.51n 0.0v 5347.49n 0.0v 5347.51n 0.0v 5397.49n 0.0v 5397.51n 0.0v 5447.49n 0.0v 5447.51n 0.0v 5497.49n 0.0v 5497.51n 0.0v 5547.49n 0.0v 5547.51n 0.0v 5597.49n 0.0v 5597.51n 0.0v 5647.49n 0.0v 5647.51n 0.0v 5697.49n 0.0v 5697.51n 0.0v 5747.49n 0.0v 5747.51n 0.0v 5797.49n 0.0v 5797.51n 0.0v 5847.49n 0.0v 5847.51n 0.0v 5897.49n 0.0v 5897.51n 0.0v 5947.49n 0.0v 5947.51n 1.8v 5997.49n 1.8v 5997.51n 1.8v 6047.49n 1.8v 6047.51n 1.8v 6097.49n 1.8v 6097.51n 0.0v 6147.49n 0.0v 6147.51n 0.0v 6197.49n 0.0v 6197.51n 0.0v 6247.49n 0.0v 6247.51n 0.0v 6297.49n 0.0v 6297.51n 0.0v 6347.49n 0.0v 6347.51n 0.0v 6397.49n 0.0v 6397.51n 0.0v 6447.49n 0.0v 6447.51n 0.0v 6497.49n 0.0v 6497.51n 0.0v 6547.49n 0.0v 6547.51n 0.0v 6597.49n 0.0v 6597.51n 1.8v 6647.49n 1.8v 6647.51n 1.8v 6697.49n 1.8v 6697.51n 1.8v 6747.49n 1.8v 6747.51n 1.8v 6797.49n 1.8v 6797.51n 1.8v 6847.49n 1.8v 6847.51n 1.8v 6897.49n 1.8v 6897.51n 1.8v 6947.49n 1.8v 6947.51n 1.8v 6997.49n 1.8v 6997.51n 1.8v 7047.49n 1.8v 7047.51n 1.8v 7097.49n 1.8v 7097.51n 1.8v 7147.49n 1.8v 7147.51n 1.8v 7197.49n 1.8v 7197.51n 0.0v 7247.49n 0.0v 7247.51n 0.0v 7297.49n 0.0v 7297.51n 0.0v 7347.49n 0.0v 7347.51n 0.0v 7397.49n 0.0v 7397.51n 0.0v 7447.49n 0.0v 7447.51n 0.0v 7497.49n 0.0v 7497.51n 1.8v 7547.49n 1.8v 7547.51n 1.8v 7597.49n 1.8v 7597.51n 1.8v 7647.49n 1.8v 7647.51n 1.8v 7697.49n 1.8v 7697.51n 1.8v 7747.49n 1.8v 7747.51n 1.8v 7797.49n 1.8v 7797.51n 1.8v 7847.49n 1.8v 7847.51n 0.0v 7897.49n 0.0v 7897.51n 0.0v 7947.49n 0.0v 7947.51n 1.8v 7997.49n 1.8v 7997.51n 1.8v 8047.49n 1.8v 8047.51n 0.0v 8097.49n 0.0v 8097.51n 0.0v 8147.49n 0.0v 8147.51n 0.0v 8197.49n 0.0v 8197.51n 0.0v 8247.49n 0.0v 8247.51n 0.0v 8297.49n 0.0v 8297.51n 0.0v 8347.49n 0.0v 8347.51n 0.0v 8397.49n 0.0v 8397.51n 0.0v 8447.49n 0.0v 8447.51n 1.8v 8497.49n 1.8v 8497.51n 1.8v 8547.49n 1.8v 8547.51n 1.8v 8597.49n 1.8v 8597.51n 1.8v 8647.49n 1.8v 8647.51n 1.8v 8697.49n 1.8v 8697.51n 1.8v 8747.49n 1.8v 8747.51n 1.8v 8797.49n 1.8v 8797.51n 1.8v 8847.49n 1.8v 8847.51n 1.8v 8897.49n 1.8v 8897.51n 0.0v 8947.49n 0.0v 8947.51n 0.0v 8997.49n 0.0v 8997.51n 1.8v 9047.49n 1.8v 9047.51n 0.0v 9097.49n 0.0v 9097.51n 0.0v 9147.49n 0.0v 9147.51n 0.0v 9197.49n 0.0v 9197.51n 0.0v 9247.49n 0.0v 9247.51n 0.0v 9297.49n 0.0v 9297.51n 0.0v 9347.49n 0.0v 9347.51n 0.0v 9397.49n 0.0v 9397.51n 0.0v 9447.49n 0.0v 9447.51n 0.0v 9497.49n 0.0v 9497.51n 0.0v 9547.49n 0.0v 9547.51n 0.0v 9597.49n 0.0v 9597.51n 1.8v 9647.49n 1.8v 9647.51n 1.8v 9697.49n 1.8v 9697.51n 1.8v 9747.49n 1.8v 9747.51n 1.8v 9797.49n 1.8v 9797.51n 1.8v 9847.49n 1.8v 9847.51n 1.8v 9897.49n 1.8v 9897.51n 1.8v 9947.49n 1.8v 9947.51n 1.8v 9997.49n 1.8v 9997.51n 0.0v 10047.49n 0.0v 10047.51n 0.0v 10097.49n 0.0v 10097.51n 0.0v 10147.49n 0.0v 10147.51n 0.0v 10197.49n 0.0v 10197.51n 0.0v 10247.49n 0.0v 10247.51n 0.0v )
* (time, data): [(0, 0), (50, 0), (100, 0), (150, 1), (200, 1), (250, 1), (300, 1), (350, 0), (400, 0), (450, 0), (500, 0), (550, 0), (600, 0), (650, 1), (700, 1), (750, 1), (800, 1), (850, 1), (900, 1), (950, 1), (1000, 1), (1050, 0), (1100, 0), (1150, 0), (1200, 0), (1250, 0), (1300, 0), (1350, 0), (1400, 1), (1450, 1), (1500, 1), (1550, 1), (1600, 0), (1650, 0), (1700, 0), (1750, 0), (1800, 0), (1850, 0), (1900, 0), (1950, 1), (2000, 1), (2050, 1), (2100, 1), (2150, 1), (2200, 1), (2250, 1), (2300, 1), (2350, 1), (2400, 1), (2450, 1), (2500, 1), (2550, 1), (2600, 1), (2650, 1), (2700, 1), (2750, 1), (2800, 1), (2850, 1), (2900, 1), (2950, 1), (3000, 1), (3050, 1), (3100, 1), (3150, 1), (3200, 0), (3250, 0), (3300, 0), (3350, 0), (3400, 0), (3450, 1), (3500, 1), (3550, 1), (3600, 1), (3650, 1), (3700, 1), (3750, 1), (3800, 1), (3850, 1), (3900, 1), (3950, 1), (4000, 1), (4050, 1), (4100, 1), (4150, 1), (4200, 1), (4250, 1), (4300, 1), (4350, 1), (4400, 1), (4450, 1), (4500, 1), (4550, 1), (4600, 1), (4650, 1), (4700, 1), (4750, 1), (4800, 0), (4850, 0), (4900, 1), (4950, 1), (5000, 1), (5050, 1), (5100, 1), (5150, 1), (5200, 1), (5250, 1), (5300, 1), (5350, 1), (5400, 1), (5450, 1), (5500, 1), (5550, 1), (5600, 0), (5650, 0), (5700, 0), (5750, 1), (5800, 1), (5850, 1), (5900, 1), (5950, 0), (6000, 0), (6050, 0), (6100, 0), (6150, 0), (6200, 0), (6250, 0), (6300, 0), (6350, 1), (6400, 1), (6450, 1), (6500, 1), (6550, 1), (6600, 1), (6650, 1), (6700, 1), (6750, 1), (6800, 1), (6850, 1), (6900, 1), (6950, 1), (7000, 1), (7050, 1), (7100, 1), (7150, 1), (7200, 1), (7250, 1), (7300, 1), (7350, 1), (7400, 1), (7450, 0), (7500, 0), (7550, 0), (7600, 0), (7650, 0), (7700, 0), (7750, 0), (7800, 0), (7850, 1), (7900, 1), (7950, 0), (8000, 0), (8050, 0), (8100, 0), (8150, 1), (8200, 1), (8250, 1), (8300, 1), (8350, 1), (8400, 1), (8450, 0), (8500, 0), (8550, 0), (8600, 0), (8650, 0), (8700, 0), (8750, 1), (8800, 1), (8850, 1), (8900, 0), (8950, 0), (9000, 0), (9050, 0), (9100, 0), (9150, 0), (9200, 0), (9250, 0), (9300, 0), (9350, 0), (9400, 1), (9450, 1), (9500, 1), (9550, 1), (9600, 0), (9650, 0), (9700, 0), (9750, 0), (9800, 0), (9850, 0), (9900, 0), (9950, 0), (10000, 1), (10050, 1), (10100, 1), (10150, 1), (10200, 1), (10250, 1)]
Vdin0_2  din0_2  0 PWL (0n 0.0v 47.49n 0.0v 47.51n 0.0v 97.49n 0.0v 97.51n 0.0v 147.49n 0.0v 147.51n 1.8v 197.49n 1.8v 197.51n 1.8v 247.49n 1.8v 247.51n 1.8v 297.49n 1.8v 297.51n 1.8v 347.49n 1.8v 347.51n 0.0v 397.49n 0.0v 397.51n 0.0v 447.49n 0.0v 447.51n 0.0v 497.49n 0.0v 497.51n 0.0v 547.49n 0.0v 547.51n 0.0v 597.49n 0.0v 597.51n 0.0v 647.49n 0.0v 647.51n 1.8v 697.49n 1.8v 697.51n 1.8v 747.49n 1.8v 747.51n 1.8v 797.49n 1.8v 797.51n 1.8v 847.49n 1.8v 847.51n 1.8v 897.49n 1.8v 897.51n 1.8v 947.49n 1.8v 947.51n 1.8v 997.49n 1.8v 997.51n 1.8v 1047.49n 1.8v 1047.51n 0.0v 1097.49n 0.0v 1097.51n 0.0v 1147.49n 0.0v 1147.51n 0.0v 1197.49n 0.0v 1197.51n 0.0v 1247.49n 0.0v 1247.51n 0.0v 1297.49n 0.0v 1297.51n 0.0v 1347.49n 0.0v 1347.51n 0.0v 1397.49n 0.0v 1397.51n 1.8v 1447.49n 1.8v 1447.51n 1.8v 1497.49n 1.8v 1497.51n 1.8v 1547.49n 1.8v 1547.51n 1.8v 1597.49n 1.8v 1597.51n 0.0v 1647.49n 0.0v 1647.51n 0.0v 1697.49n 0.0v 1697.51n 0.0v 1747.49n 0.0v 1747.51n 0.0v 1797.49n 0.0v 1797.51n 0.0v 1847.49n 0.0v 1847.51n 0.0v 1897.49n 0.0v 1897.51n 0.0v 1947.49n 0.0v 1947.51n 1.8v 1997.49n 1.8v 1997.51n 1.8v 2047.49n 1.8v 2047.51n 1.8v 2097.49n 1.8v 2097.51n 1.8v 2147.49n 1.8v 2147.51n 1.8v 2197.49n 1.8v 2197.51n 1.8v 2247.49n 1.8v 2247.51n 1.8v 2297.49n 1.8v 2297.51n 1.8v 2347.49n 1.8v 2347.51n 1.8v 2397.49n 1.8v 2397.51n 1.8v 2447.49n 1.8v 2447.51n 1.8v 2497.49n 1.8v 2497.51n 1.8v 2547.49n 1.8v 2547.51n 1.8v 2597.49n 1.8v 2597.51n 1.8v 2647.49n 1.8v 2647.51n 1.8v 2697.49n 1.8v 2697.51n 1.8v 2747.49n 1.8v 2747.51n 1.8v 2797.49n 1.8v 2797.51n 1.8v 2847.49n 1.8v 2847.51n 1.8v 2897.49n 1.8v 2897.51n 1.8v 2947.49n 1.8v 2947.51n 1.8v 2997.49n 1.8v 2997.51n 1.8v 3047.49n 1.8v 3047.51n 1.8v 3097.49n 1.8v 3097.51n 1.8v 3147.49n 1.8v 3147.51n 1.8v 3197.49n 1.8v 3197.51n 0.0v 3247.49n 0.0v 3247.51n 0.0v 3297.49n 0.0v 3297.51n 0.0v 3347.49n 0.0v 3347.51n 0.0v 3397.49n 0.0v 3397.51n 0.0v 3447.49n 0.0v 3447.51n 1.8v 3497.49n 1.8v 3497.51n 1.8v 3547.49n 1.8v 3547.51n 1.8v 3597.49n 1.8v 3597.51n 1.8v 3647.49n 1.8v 3647.51n 1.8v 3697.49n 1.8v 3697.51n 1.8v 3747.49n 1.8v 3747.51n 1.8v 3797.49n 1.8v 3797.51n 1.8v 3847.49n 1.8v 3847.51n 1.8v 3897.49n 1.8v 3897.51n 1.8v 3947.49n 1.8v 3947.51n 1.8v 3997.49n 1.8v 3997.51n 1.8v 4047.49n 1.8v 4047.51n 1.8v 4097.49n 1.8v 4097.51n 1.8v 4147.49n 1.8v 4147.51n 1.8v 4197.49n 1.8v 4197.51n 1.8v 4247.49n 1.8v 4247.51n 1.8v 4297.49n 1.8v 4297.51n 1.8v 4347.49n 1.8v 4347.51n 1.8v 4397.49n 1.8v 4397.51n 1.8v 4447.49n 1.8v 4447.51n 1.8v 4497.49n 1.8v 4497.51n 1.8v 4547.49n 1.8v 4547.51n 1.8v 4597.49n 1.8v 4597.51n 1.8v 4647.49n 1.8v 4647.51n 1.8v 4697.49n 1.8v 4697.51n 1.8v 4747.49n 1.8v 4747.51n 1.8v 4797.49n 1.8v 4797.51n 0.0v 4847.49n 0.0v 4847.51n 0.0v 4897.49n 0.0v 4897.51n 1.8v 4947.49n 1.8v 4947.51n 1.8v 4997.49n 1.8v 4997.51n 1.8v 5047.49n 1.8v 5047.51n 1.8v 5097.49n 1.8v 5097.51n 1.8v 5147.49n 1.8v 5147.51n 1.8v 5197.49n 1.8v 5197.51n 1.8v 5247.49n 1.8v 5247.51n 1.8v 5297.49n 1.8v 5297.51n 1.8v 5347.49n 1.8v 5347.51n 1.8v 5397.49n 1.8v 5397.51n 1.8v 5447.49n 1.8v 5447.51n 1.8v 5497.49n 1.8v 5497.51n 1.8v 5547.49n 1.8v 5547.51n 1.8v 5597.49n 1.8v 5597.51n 0.0v 5647.49n 0.0v 5647.51n 0.0v 5697.49n 0.0v 5697.51n 0.0v 5747.49n 0.0v 5747.51n 1.8v 5797.49n 1.8v 5797.51n 1.8v 5847.49n 1.8v 5847.51n 1.8v 5897.49n 1.8v 5897.51n 1.8v 5947.49n 1.8v 5947.51n 0.0v 5997.49n 0.0v 5997.51n 0.0v 6047.49n 0.0v 6047.51n 0.0v 6097.49n 0.0v 6097.51n 0.0v 6147.49n 0.0v 6147.51n 0.0v 6197.49n 0.0v 6197.51n 0.0v 6247.49n 0.0v 6247.51n 0.0v 6297.49n 0.0v 6297.51n 0.0v 6347.49n 0.0v 6347.51n 1.8v 6397.49n 1.8v 6397.51n 1.8v 6447.49n 1.8v 6447.51n 1.8v 6497.49n 1.8v 6497.51n 1.8v 6547.49n 1.8v 6547.51n 1.8v 6597.49n 1.8v 6597.51n 1.8v 6647.49n 1.8v 6647.51n 1.8v 6697.49n 1.8v 6697.51n 1.8v 6747.49n 1.8v 6747.51n 1.8v 6797.49n 1.8v 6797.51n 1.8v 6847.49n 1.8v 6847.51n 1.8v 6897.49n 1.8v 6897.51n 1.8v 6947.49n 1.8v 6947.51n 1.8v 6997.49n 1.8v 6997.51n 1.8v 7047.49n 1.8v 7047.51n 1.8v 7097.49n 1.8v 7097.51n 1.8v 7147.49n 1.8v 7147.51n 1.8v 7197.49n 1.8v 7197.51n 1.8v 7247.49n 1.8v 7247.51n 1.8v 7297.49n 1.8v 7297.51n 1.8v 7347.49n 1.8v 7347.51n 1.8v 7397.49n 1.8v 7397.51n 1.8v 7447.49n 1.8v 7447.51n 0.0v 7497.49n 0.0v 7497.51n 0.0v 7547.49n 0.0v 7547.51n 0.0v 7597.49n 0.0v 7597.51n 0.0v 7647.49n 0.0v 7647.51n 0.0v 7697.49n 0.0v 7697.51n 0.0v 7747.49n 0.0v 7747.51n 0.0v 7797.49n 0.0v 7797.51n 0.0v 7847.49n 0.0v 7847.51n 1.8v 7897.49n 1.8v 7897.51n 1.8v 7947.49n 1.8v 7947.51n 0.0v 7997.49n 0.0v 7997.51n 0.0v 8047.49n 0.0v 8047.51n 0.0v 8097.49n 0.0v 8097.51n 0.0v 8147.49n 0.0v 8147.51n 1.8v 8197.49n 1.8v 8197.51n 1.8v 8247.49n 1.8v 8247.51n 1.8v 8297.49n 1.8v 8297.51n 1.8v 8347.49n 1.8v 8347.51n 1.8v 8397.49n 1.8v 8397.51n 1.8v 8447.49n 1.8v 8447.51n 0.0v 8497.49n 0.0v 8497.51n 0.0v 8547.49n 0.0v 8547.51n 0.0v 8597.49n 0.0v 8597.51n 0.0v 8647.49n 0.0v 8647.51n 0.0v 8697.49n 0.0v 8697.51n 0.0v 8747.49n 0.0v 8747.51n 1.8v 8797.49n 1.8v 8797.51n 1.8v 8847.49n 1.8v 8847.51n 1.8v 8897.49n 1.8v 8897.51n 0.0v 8947.49n 0.0v 8947.51n 0.0v 8997.49n 0.0v 8997.51n 0.0v 9047.49n 0.0v 9047.51n 0.0v 9097.49n 0.0v 9097.51n 0.0v 9147.49n 0.0v 9147.51n 0.0v 9197.49n 0.0v 9197.51n 0.0v 9247.49n 0.0v 9247.51n 0.0v 9297.49n 0.0v 9297.51n 0.0v 9347.49n 0.0v 9347.51n 0.0v 9397.49n 0.0v 9397.51n 1.8v 9447.49n 1.8v 9447.51n 1.8v 9497.49n 1.8v 9497.51n 1.8v 9547.49n 1.8v 9547.51n 1.8v 9597.49n 1.8v 9597.51n 0.0v 9647.49n 0.0v 9647.51n 0.0v 9697.49n 0.0v 9697.51n 0.0v 9747.49n 0.0v 9747.51n 0.0v 9797.49n 0.0v 9797.51n 0.0v 9847.49n 0.0v 9847.51n 0.0v 9897.49n 0.0v 9897.51n 0.0v 9947.49n 0.0v 9947.51n 0.0v 9997.49n 0.0v 9997.51n 1.8v 10047.49n 1.8v 10047.51n 1.8v 10097.49n 1.8v 10097.51n 1.8v 10147.49n 1.8v 10147.51n 1.8v 10197.49n 1.8v 10197.51n 1.8v 10247.49n 1.8v 10247.51n 1.8v )
* (time, data): [(0, 0), (50, 0), (100, 0), (150, 0), (200, 0), (250, 0), (300, 0), (350, 1), (400, 1), (450, 1), (500, 1), (550, 1), (600, 1), (650, 1), (700, 1), (750, 1), (800, 1), (850, 1), (900, 1), (950, 1), (1000, 1), (1050, 0), (1100, 0), (1150, 0), (1200, 0), (1250, 0), (1300, 0), (1350, 0), (1400, 1), (1450, 1), (1500, 0), (1550, 0), (1600, 1), (1650, 1), (1700, 1), (1750, 1), (1800, 1), (1850, 1), (1900, 1), (1950, 1), (2000, 1), (2050, 1), (2100, 1), (2150, 1), (2200, 1), (2250, 0), (2300, 0), (2350, 0), (2400, 0), (2450, 0), (2500, 0), (2550, 0), (2600, 0), (2650, 0), (2700, 0), (2750, 0), (2800, 1), (2850, 0), (2900, 0), (2950, 0), (3000, 0), (3050, 0), (3100, 1), (3150, 1), (3200, 1), (3250, 1), (3300, 1), (3350, 1), (3400, 1), (3450, 0), (3500, 0), (3550, 0), (3600, 0), (3650, 1), (3700, 1), (3750, 1), (3800, 1), (3850, 1), (3900, 1), (3950, 1), (4000, 1), (4050, 1), (4100, 0), (4150, 0), (4200, 0), (4250, 0), (4300, 0), (4350, 0), (4400, 0), (4450, 0), (4500, 1), (4550, 1), (4600, 1), (4650, 1), (4700, 1), (4750, 0), (4800, 1), (4850, 1), (4900, 0), (4950, 0), (5000, 0), (5050, 0), (5100, 0), (5150, 0), (5200, 0), (5250, 0), (5300, 0), (5350, 0), (5400, 0), (5450, 0), (5500, 0), (5550, 0), (5600, 1), (5650, 1), (5700, 1), (5750, 0), (5800, 0), (5850, 0), (5900, 0), (5950, 0), (6000, 1), (6050, 1), (6100, 1), (6150, 1), (6200, 1), (6250, 1), (6300, 1), (6350, 0), (6400, 0), (6450, 0), (6500, 0), (6550, 0), (6600, 1), (6650, 1), (6700, 1), (6750, 1), (6800, 1), (6850, 1), (6900, 1), (6950, 1), (7000, 1), (7050, 1), (7100, 1), (7150, 1), (7200, 0), (7250, 0), (7300, 0), (7350, 0), (7400, 0), (7450, 1), (7500, 0), (7550, 0), (7600, 0), (7650, 0), (7700, 1), (7750, 1), (7800, 1), (7850, 1), (7900, 1), (7950, 1), (8000, 1), (8050, 0), (8100, 0), (8150, 0), (8200, 0), (8250, 0), (8300, 0), (8350, 0), (8400, 0), (8450, 0), (8500, 0), (8550, 0), (8600, 0), (8650, 0), (8700, 0), (8750, 0), (8800, 0), (8850, 0), (8900, 1), (8950, 1), (9000, 1), (9050, 0), (9100, 0), (9150, 0), (9200, 0), (9250, 0), (9300, 0), (9350, 0), (9400, 0), (9450, 0), (9500, 0), (9550, 0), (9600, 1), (9650, 1), (9700, 1), (9750, 1), (9800, 1), (9850, 1), (9900, 1), (9950, 1), (10000, 0), (10050, 0), (10100, 0), (10150, 0), (10200, 0), (10250, 0)]
Vdin0_3  din0_3  0 PWL (0n 0.0v 47.49n 0.0v 47.51n 0.0v 97.49n 0.0v 97.51n 0.0v 147.49n 0.0v 147.51n 0.0v 197.49n 0.0v 197.51n 0.0v 247.49n 0.0v 247.51n 0.0v 297.49n 0.0v 297.51n 0.0v 347.49n 0.0v 347.51n 1.8v 397.49n 1.8v 397.51n 1.8v 447.49n 1.8v 447.51n 1.8v 497.49n 1.8v 497.51n 1.8v 547.49n 1.8v 547.51n 1.8v 597.49n 1.8v 597.51n 1.8v 647.49n 1.8v 647.51n 1.8v 697.49n 1.8v 697.51n 1.8v 747.49n 1.8v 747.51n 1.8v 797.49n 1.8v 797.51n 1.8v 847.49n 1.8v 847.51n 1.8v 897.49n 1.8v 897.51n 1.8v 947.49n 1.8v 947.51n 1.8v 997.49n 1.8v 997.51n 1.8v 1047.49n 1.8v 1047.51n 0.0v 1097.49n 0.0v 1097.51n 0.0v 1147.49n 0.0v 1147.51n 0.0v 1197.49n 0.0v 1197.51n 0.0v 1247.49n 0.0v 1247.51n 0.0v 1297.49n 0.0v 1297.51n 0.0v 1347.49n 0.0v 1347.51n 0.0v 1397.49n 0.0v 1397.51n 1.8v 1447.49n 1.8v 1447.51n 1.8v 1497.49n 1.8v 1497.51n 0.0v 1547.49n 0.0v 1547.51n 0.0v 1597.49n 0.0v 1597.51n 1.8v 1647.49n 1.8v 1647.51n 1.8v 1697.49n 1.8v 1697.51n 1.8v 1747.49n 1.8v 1747.51n 1.8v 1797.49n 1.8v 1797.51n 1.8v 1847.49n 1.8v 1847.51n 1.8v 1897.49n 1.8v 1897.51n 1.8v 1947.49n 1.8v 1947.51n 1.8v 1997.49n 1.8v 1997.51n 1.8v 2047.49n 1.8v 2047.51n 1.8v 2097.49n 1.8v 2097.51n 1.8v 2147.49n 1.8v 2147.51n 1.8v 2197.49n 1.8v 2197.51n 1.8v 2247.49n 1.8v 2247.51n 0.0v 2297.49n 0.0v 2297.51n 0.0v 2347.49n 0.0v 2347.51n 0.0v 2397.49n 0.0v 2397.51n 0.0v 2447.49n 0.0v 2447.51n 0.0v 2497.49n 0.0v 2497.51n 0.0v 2547.49n 0.0v 2547.51n 0.0v 2597.49n 0.0v 2597.51n 0.0v 2647.49n 0.0v 2647.51n 0.0v 2697.49n 0.0v 2697.51n 0.0v 2747.49n 0.0v 2747.51n 0.0v 2797.49n 0.0v 2797.51n 1.8v 2847.49n 1.8v 2847.51n 0.0v 2897.49n 0.0v 2897.51n 0.0v 2947.49n 0.0v 2947.51n 0.0v 2997.49n 0.0v 2997.51n 0.0v 3047.49n 0.0v 3047.51n 0.0v 3097.49n 0.0v 3097.51n 1.8v 3147.49n 1.8v 3147.51n 1.8v 3197.49n 1.8v 3197.51n 1.8v 3247.49n 1.8v 3247.51n 1.8v 3297.49n 1.8v 3297.51n 1.8v 3347.49n 1.8v 3347.51n 1.8v 3397.49n 1.8v 3397.51n 1.8v 3447.49n 1.8v 3447.51n 0.0v 3497.49n 0.0v 3497.51n 0.0v 3547.49n 0.0v 3547.51n 0.0v 3597.49n 0.0v 3597.51n 0.0v 3647.49n 0.0v 3647.51n 1.8v 3697.49n 1.8v 3697.51n 1.8v 3747.49n 1.8v 3747.51n 1.8v 3797.49n 1.8v 3797.51n 1.8v 3847.49n 1.8v 3847.51n 1.8v 3897.49n 1.8v 3897.51n 1.8v 3947.49n 1.8v 3947.51n 1.8v 3997.49n 1.8v 3997.51n 1.8v 4047.49n 1.8v 4047.51n 1.8v 4097.49n 1.8v 4097.51n 0.0v 4147.49n 0.0v 4147.51n 0.0v 4197.49n 0.0v 4197.51n 0.0v 4247.49n 0.0v 4247.51n 0.0v 4297.49n 0.0v 4297.51n 0.0v 4347.49n 0.0v 4347.51n 0.0v 4397.49n 0.0v 4397.51n 0.0v 4447.49n 0.0v 4447.51n 0.0v 4497.49n 0.0v 4497.51n 1.8v 4547.49n 1.8v 4547.51n 1.8v 4597.49n 1.8v 4597.51n 1.8v 4647.49n 1.8v 4647.51n 1.8v 4697.49n 1.8v 4697.51n 1.8v 4747.49n 1.8v 4747.51n 0.0v 4797.49n 0.0v 4797.51n 1.8v 4847.49n 1.8v 4847.51n 1.8v 4897.49n 1.8v 4897.51n 0.0v 4947.49n 0.0v 4947.51n 0.0v 4997.49n 0.0v 4997.51n 0.0v 5047.49n 0.0v 5047.51n 0.0v 5097.49n 0.0v 5097.51n 0.0v 5147.49n 0.0v 5147.51n 0.0v 5197.49n 0.0v 5197.51n 0.0v 5247.49n 0.0v 5247.51n 0.0v 5297.49n 0.0v 5297.51n 0.0v 5347.49n 0.0v 5347.51n 0.0v 5397.49n 0.0v 5397.51n 0.0v 5447.49n 0.0v 5447.51n 0.0v 5497.49n 0.0v 5497.51n 0.0v 5547.49n 0.0v 5547.51n 0.0v 5597.49n 0.0v 5597.51n 1.8v 5647.49n 1.8v 5647.51n 1.8v 5697.49n 1.8v 5697.51n 1.8v 5747.49n 1.8v 5747.51n 0.0v 5797.49n 0.0v 5797.51n 0.0v 5847.49n 0.0v 5847.51n 0.0v 5897.49n 0.0v 5897.51n 0.0v 5947.49n 0.0v 5947.51n 0.0v 5997.49n 0.0v 5997.51n 1.8v 6047.49n 1.8v 6047.51n 1.8v 6097.49n 1.8v 6097.51n 1.8v 6147.49n 1.8v 6147.51n 1.8v 6197.49n 1.8v 6197.51n 1.8v 6247.49n 1.8v 6247.51n 1.8v 6297.49n 1.8v 6297.51n 1.8v 6347.49n 1.8v 6347.51n 0.0v 6397.49n 0.0v 6397.51n 0.0v 6447.49n 0.0v 6447.51n 0.0v 6497.49n 0.0v 6497.51n 0.0v 6547.49n 0.0v 6547.51n 0.0v 6597.49n 0.0v 6597.51n 1.8v 6647.49n 1.8v 6647.51n 1.8v 6697.49n 1.8v 6697.51n 1.8v 6747.49n 1.8v 6747.51n 1.8v 6797.49n 1.8v 6797.51n 1.8v 6847.49n 1.8v 6847.51n 1.8v 6897.49n 1.8v 6897.51n 1.8v 6947.49n 1.8v 6947.51n 1.8v 6997.49n 1.8v 6997.51n 1.8v 7047.49n 1.8v 7047.51n 1.8v 7097.49n 1.8v 7097.51n 1.8v 7147.49n 1.8v 7147.51n 1.8v 7197.49n 1.8v 7197.51n 0.0v 7247.49n 0.0v 7247.51n 0.0v 7297.49n 0.0v 7297.51n 0.0v 7347.49n 0.0v 7347.51n 0.0v 7397.49n 0.0v 7397.51n 0.0v 7447.49n 0.0v 7447.51n 1.8v 7497.49n 1.8v 7497.51n 0.0v 7547.49n 0.0v 7547.51n 0.0v 7597.49n 0.0v 7597.51n 0.0v 7647.49n 0.0v 7647.51n 0.0v 7697.49n 0.0v 7697.51n 1.8v 7747.49n 1.8v 7747.51n 1.8v 7797.49n 1.8v 7797.51n 1.8v 7847.49n 1.8v 7847.51n 1.8v 7897.49n 1.8v 7897.51n 1.8v 7947.49n 1.8v 7947.51n 1.8v 7997.49n 1.8v 7997.51n 1.8v 8047.49n 1.8v 8047.51n 0.0v 8097.49n 0.0v 8097.51n 0.0v 8147.49n 0.0v 8147.51n 0.0v 8197.49n 0.0v 8197.51n 0.0v 8247.49n 0.0v 8247.51n 0.0v 8297.49n 0.0v 8297.51n 0.0v 8347.49n 0.0v 8347.51n 0.0v 8397.49n 0.0v 8397.51n 0.0v 8447.49n 0.0v 8447.51n 0.0v 8497.49n 0.0v 8497.51n 0.0v 8547.49n 0.0v 8547.51n 0.0v 8597.49n 0.0v 8597.51n 0.0v 8647.49n 0.0v 8647.51n 0.0v 8697.49n 0.0v 8697.51n 0.0v 8747.49n 0.0v 8747.51n 0.0v 8797.49n 0.0v 8797.51n 0.0v 8847.49n 0.0v 8847.51n 0.0v 8897.49n 0.0v 8897.51n 1.8v 8947.49n 1.8v 8947.51n 1.8v 8997.49n 1.8v 8997.51n 1.8v 9047.49n 1.8v 9047.51n 0.0v 9097.49n 0.0v 9097.51n 0.0v 9147.49n 0.0v 9147.51n 0.0v 9197.49n 0.0v 9197.51n 0.0v 9247.49n 0.0v 9247.51n 0.0v 9297.49n 0.0v 9297.51n 0.0v 9347.49n 0.0v 9347.51n 0.0v 9397.49n 0.0v 9397.51n 0.0v 9447.49n 0.0v 9447.51n 0.0v 9497.49n 0.0v 9497.51n 0.0v 9547.49n 0.0v 9547.51n 0.0v 9597.49n 0.0v 9597.51n 1.8v 9647.49n 1.8v 9647.51n 1.8v 9697.49n 1.8v 9697.51n 1.8v 9747.49n 1.8v 9747.51n 1.8v 9797.49n 1.8v 9797.51n 1.8v 9847.49n 1.8v 9847.51n 1.8v 9897.49n 1.8v 9897.51n 1.8v 9947.49n 1.8v 9947.51n 1.8v 9997.49n 1.8v 9997.51n 0.0v 10047.49n 0.0v 10047.51n 0.0v 10097.49n 0.0v 10097.51n 0.0v 10147.49n 0.0v 10147.51n 0.0v 10197.49n 0.0v 10197.51n 0.0v 10247.49n 0.0v 10247.51n 0.0v )
* (time, data): [(0, 0), (50, 1), (100, 0), (150, 0), (200, 0), (250, 0), (300, 0), (350, 0), (400, 0), (450, 0), (500, 0), (550, 0), (600, 0), (650, 0), (700, 0), (750, 0), (800, 0), (850, 0), (900, 0), (950, 0), (1000, 0), (1050, 1), (1100, 1), (1150, 0), (1200, 0), (1250, 0), (1300, 0), (1350, 0), (1400, 0), (1450, 0), (1500, 1), (1550, 1), (1600, 1), (1650, 1), (1700, 1), (1750, 1), (1800, 0), (1850, 0), (1900, 0), (1950, 1), (2000, 1), (2050, 1), (2100, 1), (2150, 1), (2200, 1), (2250, 0), (2300, 0), (2350, 0), (2400, 0), (2450, 0), (2500, 0), (2550, 0), (2600, 0), (2650, 0), (2700, 0), (2750, 0), (2800, 0), (2850, 0), (2900, 0), (2950, 0), (3000, 0), (3050, 0), (3100, 1), (3150, 1), (3200, 1), (3250, 1), (3300, 1), (3350, 1), (3400, 1), (3450, 0), (3500, 0), (3550, 0), (3600, 0), (3650, 0), (3700, 0), (3750, 0), (3800, 0), (3850, 0), (3900, 0), (3950, 0), (4000, 0), (4050, 0), (4100, 0), (4150, 0), (4200, 0), (4250, 0), (4300, 0), (4350, 0), (4400, 0), (4450, 0), (4500, 0), (4550, 0), (4600, 0), (4650, 0), (4700, 0), (4750, 1), (4800, 0), (4850, 0), (4900, 1), (4950, 1), (5000, 1), (5050, 1), (5100, 1), (5150, 1), (5200, 1), (5250, 1), (5300, 1), (5350, 1), (5400, 1), (5450, 1), (5500, 0), (5550, 0), (5600, 1), (5650, 1), (5700, 1), (5750, 0), (5800, 0), (5850, 0), (5900, 0), (5950, 1), (6000, 0), (6050, 0), (6100, 1), (6150, 1), (6200, 1), (6250, 1), (6300, 1), (6350, 1), (6400, 1), (6450, 1), (6500, 1), (6550, 1), (6600, 0), (6650, 0), (6700, 0), (6750, 0), (6800, 0), (6850, 0), (6900, 0), (6950, 0), (7000, 0), (7050, 0), (7100, 0), (7150, 0), (7200, 1), (7250, 1), (7300, 1), (7350, 1), (7400, 1), (7450, 1), (7500, 1), (7550, 1), (7600, 1), (7650, 1), (7700, 1), (7750, 1), (7800, 0), (7850, 1), (7900, 1), (7950, 1), (8000, 1), (8050, 1), (8100, 1), (8150, 0), (8200, 0), (8250, 0), (8300, 0), (8350, 0), (8400, 0), (8450, 1), (8500, 1), (8550, 1), (8600, 1), (8650, 1), (8700, 1), (8750, 0), (8800, 0), (8850, 0), (8900, 0), (8950, 0), (9000, 1), (9050, 0), (9100, 0), (9150, 0), (9200, 0), (9250, 0), (9300, 0), (9350, 0), (9400, 0), (9450, 0), (9500, 0), (9550, 0), (9600, 1), (9650, 1), (9700, 1), (9750, 1), (9800, 1), (9850, 1), (9900, 1), (9950, 1), (10000, 0), (10050, 0), (10100, 0), (10150, 0), (10200, 0), (10250, 0)]
Vdin0_4  din0_4  0 PWL (0n 0.0v 47.49n 0.0v 47.51n 1.8v 97.49n 1.8v 97.51n 0.0v 147.49n 0.0v 147.51n 0.0v 197.49n 0.0v 197.51n 0.0v 247.49n 0.0v 247.51n 0.0v 297.49n 0.0v 297.51n 0.0v 347.49n 0.0v 347.51n 0.0v 397.49n 0.0v 397.51n 0.0v 447.49n 0.0v 447.51n 0.0v 497.49n 0.0v 497.51n 0.0v 547.49n 0.0v 547.51n 0.0v 597.49n 0.0v 597.51n 0.0v 647.49n 0.0v 647.51n 0.0v 697.49n 0.0v 697.51n 0.0v 747.49n 0.0v 747.51n 0.0v 797.49n 0.0v 797.51n 0.0v 847.49n 0.0v 847.51n 0.0v 897.49n 0.0v 897.51n 0.0v 947.49n 0.0v 947.51n 0.0v 997.49n 0.0v 997.51n 0.0v 1047.49n 0.0v 1047.51n 1.8v 1097.49n 1.8v 1097.51n 1.8v 1147.49n 1.8v 1147.51n 0.0v 1197.49n 0.0v 1197.51n 0.0v 1247.49n 0.0v 1247.51n 0.0v 1297.49n 0.0v 1297.51n 0.0v 1347.49n 0.0v 1347.51n 0.0v 1397.49n 0.0v 1397.51n 0.0v 1447.49n 0.0v 1447.51n 0.0v 1497.49n 0.0v 1497.51n 1.8v 1547.49n 1.8v 1547.51n 1.8v 1597.49n 1.8v 1597.51n 1.8v 1647.49n 1.8v 1647.51n 1.8v 1697.49n 1.8v 1697.51n 1.8v 1747.49n 1.8v 1747.51n 1.8v 1797.49n 1.8v 1797.51n 0.0v 1847.49n 0.0v 1847.51n 0.0v 1897.49n 0.0v 1897.51n 0.0v 1947.49n 0.0v 1947.51n 1.8v 1997.49n 1.8v 1997.51n 1.8v 2047.49n 1.8v 2047.51n 1.8v 2097.49n 1.8v 2097.51n 1.8v 2147.49n 1.8v 2147.51n 1.8v 2197.49n 1.8v 2197.51n 1.8v 2247.49n 1.8v 2247.51n 0.0v 2297.49n 0.0v 2297.51n 0.0v 2347.49n 0.0v 2347.51n 0.0v 2397.49n 0.0v 2397.51n 0.0v 2447.49n 0.0v 2447.51n 0.0v 2497.49n 0.0v 2497.51n 0.0v 2547.49n 0.0v 2547.51n 0.0v 2597.49n 0.0v 2597.51n 0.0v 2647.49n 0.0v 2647.51n 0.0v 2697.49n 0.0v 2697.51n 0.0v 2747.49n 0.0v 2747.51n 0.0v 2797.49n 0.0v 2797.51n 0.0v 2847.49n 0.0v 2847.51n 0.0v 2897.49n 0.0v 2897.51n 0.0v 2947.49n 0.0v 2947.51n 0.0v 2997.49n 0.0v 2997.51n 0.0v 3047.49n 0.0v 3047.51n 0.0v 3097.49n 0.0v 3097.51n 1.8v 3147.49n 1.8v 3147.51n 1.8v 3197.49n 1.8v 3197.51n 1.8v 3247.49n 1.8v 3247.51n 1.8v 3297.49n 1.8v 3297.51n 1.8v 3347.49n 1.8v 3347.51n 1.8v 3397.49n 1.8v 3397.51n 1.8v 3447.49n 1.8v 3447.51n 0.0v 3497.49n 0.0v 3497.51n 0.0v 3547.49n 0.0v 3547.51n 0.0v 3597.49n 0.0v 3597.51n 0.0v 3647.49n 0.0v 3647.51n 0.0v 3697.49n 0.0v 3697.51n 0.0v 3747.49n 0.0v 3747.51n 0.0v 3797.49n 0.0v 3797.51n 0.0v 3847.49n 0.0v 3847.51n 0.0v 3897.49n 0.0v 3897.51n 0.0v 3947.49n 0.0v 3947.51n 0.0v 3997.49n 0.0v 3997.51n 0.0v 4047.49n 0.0v 4047.51n 0.0v 4097.49n 0.0v 4097.51n 0.0v 4147.49n 0.0v 4147.51n 0.0v 4197.49n 0.0v 4197.51n 0.0v 4247.49n 0.0v 4247.51n 0.0v 4297.49n 0.0v 4297.51n 0.0v 4347.49n 0.0v 4347.51n 0.0v 4397.49n 0.0v 4397.51n 0.0v 4447.49n 0.0v 4447.51n 0.0v 4497.49n 0.0v 4497.51n 0.0v 4547.49n 0.0v 4547.51n 0.0v 4597.49n 0.0v 4597.51n 0.0v 4647.49n 0.0v 4647.51n 0.0v 4697.49n 0.0v 4697.51n 0.0v 4747.49n 0.0v 4747.51n 1.8v 4797.49n 1.8v 4797.51n 0.0v 4847.49n 0.0v 4847.51n 0.0v 4897.49n 0.0v 4897.51n 1.8v 4947.49n 1.8v 4947.51n 1.8v 4997.49n 1.8v 4997.51n 1.8v 5047.49n 1.8v 5047.51n 1.8v 5097.49n 1.8v 5097.51n 1.8v 5147.49n 1.8v 5147.51n 1.8v 5197.49n 1.8v 5197.51n 1.8v 5247.49n 1.8v 5247.51n 1.8v 5297.49n 1.8v 5297.51n 1.8v 5347.49n 1.8v 5347.51n 1.8v 5397.49n 1.8v 5397.51n 1.8v 5447.49n 1.8v 5447.51n 1.8v 5497.49n 1.8v 5497.51n 0.0v 5547.49n 0.0v 5547.51n 0.0v 5597.49n 0.0v 5597.51n 1.8v 5647.49n 1.8v 5647.51n 1.8v 5697.49n 1.8v 5697.51n 1.8v 5747.49n 1.8v 5747.51n 0.0v 5797.49n 0.0v 5797.51n 0.0v 5847.49n 0.0v 5847.51n 0.0v 5897.49n 0.0v 5897.51n 0.0v 5947.49n 0.0v 5947.51n 1.8v 5997.49n 1.8v 5997.51n 0.0v 6047.49n 0.0v 6047.51n 0.0v 6097.49n 0.0v 6097.51n 1.8v 6147.49n 1.8v 6147.51n 1.8v 6197.49n 1.8v 6197.51n 1.8v 6247.49n 1.8v 6247.51n 1.8v 6297.49n 1.8v 6297.51n 1.8v 6347.49n 1.8v 6347.51n 1.8v 6397.49n 1.8v 6397.51n 1.8v 6447.49n 1.8v 6447.51n 1.8v 6497.49n 1.8v 6497.51n 1.8v 6547.49n 1.8v 6547.51n 1.8v 6597.49n 1.8v 6597.51n 0.0v 6647.49n 0.0v 6647.51n 0.0v 6697.49n 0.0v 6697.51n 0.0v 6747.49n 0.0v 6747.51n 0.0v 6797.49n 0.0v 6797.51n 0.0v 6847.49n 0.0v 6847.51n 0.0v 6897.49n 0.0v 6897.51n 0.0v 6947.49n 0.0v 6947.51n 0.0v 6997.49n 0.0v 6997.51n 0.0v 7047.49n 0.0v 7047.51n 0.0v 7097.49n 0.0v 7097.51n 0.0v 7147.49n 0.0v 7147.51n 0.0v 7197.49n 0.0v 7197.51n 1.8v 7247.49n 1.8v 7247.51n 1.8v 7297.49n 1.8v 7297.51n 1.8v 7347.49n 1.8v 7347.51n 1.8v 7397.49n 1.8v 7397.51n 1.8v 7447.49n 1.8v 7447.51n 1.8v 7497.49n 1.8v 7497.51n 1.8v 7547.49n 1.8v 7547.51n 1.8v 7597.49n 1.8v 7597.51n 1.8v 7647.49n 1.8v 7647.51n 1.8v 7697.49n 1.8v 7697.51n 1.8v 7747.49n 1.8v 7747.51n 1.8v 7797.49n 1.8v 7797.51n 0.0v 7847.49n 0.0v 7847.51n 1.8v 7897.49n 1.8v 7897.51n 1.8v 7947.49n 1.8v 7947.51n 1.8v 7997.49n 1.8v 7997.51n 1.8v 8047.49n 1.8v 8047.51n 1.8v 8097.49n 1.8v 8097.51n 1.8v 8147.49n 1.8v 8147.51n 0.0v 8197.49n 0.0v 8197.51n 0.0v 8247.49n 0.0v 8247.51n 0.0v 8297.49n 0.0v 8297.51n 0.0v 8347.49n 0.0v 8347.51n 0.0v 8397.49n 0.0v 8397.51n 0.0v 8447.49n 0.0v 8447.51n 1.8v 8497.49n 1.8v 8497.51n 1.8v 8547.49n 1.8v 8547.51n 1.8v 8597.49n 1.8v 8597.51n 1.8v 8647.49n 1.8v 8647.51n 1.8v 8697.49n 1.8v 8697.51n 1.8v 8747.49n 1.8v 8747.51n 0.0v 8797.49n 0.0v 8797.51n 0.0v 8847.49n 0.0v 8847.51n 0.0v 8897.49n 0.0v 8897.51n 0.0v 8947.49n 0.0v 8947.51n 0.0v 8997.49n 0.0v 8997.51n 1.8v 9047.49n 1.8v 9047.51n 0.0v 9097.49n 0.0v 9097.51n 0.0v 9147.49n 0.0v 9147.51n 0.0v 9197.49n 0.0v 9197.51n 0.0v 9247.49n 0.0v 9247.51n 0.0v 9297.49n 0.0v 9297.51n 0.0v 9347.49n 0.0v 9347.51n 0.0v 9397.49n 0.0v 9397.51n 0.0v 9447.49n 0.0v 9447.51n 0.0v 9497.49n 0.0v 9497.51n 0.0v 9547.49n 0.0v 9547.51n 0.0v 9597.49n 0.0v 9597.51n 1.8v 9647.49n 1.8v 9647.51n 1.8v 9697.49n 1.8v 9697.51n 1.8v 9747.49n 1.8v 9747.51n 1.8v 9797.49n 1.8v 9797.51n 1.8v 9847.49n 1.8v 9847.51n 1.8v 9897.49n 1.8v 9897.51n 1.8v 9947.49n 1.8v 9947.51n 1.8v 9997.49n 1.8v 9997.51n 0.0v 10047.49n 0.0v 10047.51n 0.0v 10097.49n 0.0v 10097.51n 0.0v 10147.49n 0.0v 10147.51n 0.0v 10197.49n 0.0v 10197.51n 0.0v 10247.49n 0.0v 10247.51n 0.0v )
* (time, data): [(0, 0), (50, 0), (100, 0), (150, 0), (200, 0), (250, 0), (300, 0), (350, 1), (400, 1), (450, 0), (500, 0), (550, 0), (600, 0), (650, 0), (700, 0), (750, 0), (800, 0), (850, 0), (900, 0), (950, 0), (1000, 0), (1050, 0), (1100, 0), (1150, 1), (1200, 1), (1250, 1), (1300, 1), (1350, 1), (1400, 1), (1450, 1), (1500, 1), (1550, 1), (1600, 1), (1650, 1), (1700, 1), (1750, 1), (1800, 0), (1850, 0), (1900, 0), (1950, 1), (2000, 1), (2050, 1), (2100, 1), (2150, 1), (2200, 1), (2250, 0), (2300, 0), (2350, 0), (2400, 0), (2450, 0), (2500, 0), (2550, 0), (2600, 0), (2650, 0), (2700, 0), (2750, 0), (2800, 1), (2850, 1), (2900, 1), (2950, 1), (3000, 1), (3050, 1), (3100, 1), (3150, 1), (3200, 1), (3250, 1), (3300, 1), (3350, 1), (3400, 1), (3450, 1), (3500, 1), (3550, 1), (3600, 1), (3650, 0), (3700, 0), (3750, 0), (3800, 0), (3850, 0), (3900, 0), (3950, 0), (4000, 0), (4050, 0), (4100, 0), (4150, 0), (4200, 0), (4250, 0), (4300, 0), (4350, 0), (4400, 0), (4450, 0), (4500, 1), (4550, 1), (4600, 1), (4650, 1), (4700, 1), (4750, 0), (4800, 0), (4850, 0), (4900, 1), (4950, 1), (5000, 1), (5050, 1), (5100, 1), (5150, 1), (5200, 1), (5250, 1), (5300, 0), (5350, 0), (5400, 0), (5450, 0), (5500, 1), (5550, 1), (5600, 1), (5650, 1), (5700, 1), (5750, 1), (5800, 1), (5850, 1), (5900, 1), (5950, 0), (6000, 1), (6050, 1), (6100, 0), (6150, 0), (6200, 0), (6250, 0), (6300, 0), (6350, 1), (6400, 1), (6450, 1), (6500, 1), (6550, 1), (6600, 0), (6650, 0), (6700, 0), (6750, 0), (6800, 0), (6850, 0), (6900, 0), (6950, 0), (7000, 0), (7050, 0), (7100, 0), (7150, 0), (7200, 1), (7250, 1), (7300, 1), (7350, 1), (7400, 1), (7450, 1), (7500, 0), (7550, 0), (7600, 0), (7650, 0), (7700, 1), (7750, 1), (7800, 1), (7850, 0), (7900, 0), (7950, 1), (8000, 1), (8050, 1), (8100, 1), (8150, 1), (8200, 1), (8250, 1), (8300, 1), (8350, 1), (8400, 1), (8450, 0), (8500, 0), (8550, 0), (8600, 0), (8650, 0), (8700, 0), (8750, 0), (8800, 0), (8850, 0), (8900, 1), (8950, 1), (9000, 0), (9050, 0), (9100, 0), (9150, 0), (9200, 0), (9250, 0), (9300, 0), (9350, 0), (9400, 0), (9450, 0), (9500, 0), (9550, 0), (9600, 0), (9650, 0), (9700, 0), (9750, 0), (9800, 0), (9850, 0), (9900, 0), (9950, 0), (10000, 1), (10050, 1), (10100, 1), (10150, 0), (10200, 0), (10250, 0)]
Vdin0_5  din0_5  0 PWL (0n 0.0v 47.49n 0.0v 47.51n 0.0v 97.49n 0.0v 97.51n 0.0v 147.49n 0.0v 147.51n 0.0v 197.49n 0.0v 197.51n 0.0v 247.49n 0.0v 247.51n 0.0v 297.49n 0.0v 297.51n 0.0v 347.49n 0.0v 347.51n 1.8v 397.49n 1.8v 397.51n 1.8v 447.49n 1.8v 447.51n 0.0v 497.49n 0.0v 497.51n 0.0v 547.49n 0.0v 547.51n 0.0v 597.49n 0.0v 597.51n 0.0v 647.49n 0.0v 647.51n 0.0v 697.49n 0.0v 697.51n 0.0v 747.49n 0.0v 747.51n 0.0v 797.49n 0.0v 797.51n 0.0v 847.49n 0.0v 847.51n 0.0v 897.49n 0.0v 897.51n 0.0v 947.49n 0.0v 947.51n 0.0v 997.49n 0.0v 997.51n 0.0v 1047.49n 0.0v 1047.51n 0.0v 1097.49n 0.0v 1097.51n 0.0v 1147.49n 0.0v 1147.51n 1.8v 1197.49n 1.8v 1197.51n 1.8v 1247.49n 1.8v 1247.51n 1.8v 1297.49n 1.8v 1297.51n 1.8v 1347.49n 1.8v 1347.51n 1.8v 1397.49n 1.8v 1397.51n 1.8v 1447.49n 1.8v 1447.51n 1.8v 1497.49n 1.8v 1497.51n 1.8v 1547.49n 1.8v 1547.51n 1.8v 1597.49n 1.8v 1597.51n 1.8v 1647.49n 1.8v 1647.51n 1.8v 1697.49n 1.8v 1697.51n 1.8v 1747.49n 1.8v 1747.51n 1.8v 1797.49n 1.8v 1797.51n 0.0v 1847.49n 0.0v 1847.51n 0.0v 1897.49n 0.0v 1897.51n 0.0v 1947.49n 0.0v 1947.51n 1.8v 1997.49n 1.8v 1997.51n 1.8v 2047.49n 1.8v 2047.51n 1.8v 2097.49n 1.8v 2097.51n 1.8v 2147.49n 1.8v 2147.51n 1.8v 2197.49n 1.8v 2197.51n 1.8v 2247.49n 1.8v 2247.51n 0.0v 2297.49n 0.0v 2297.51n 0.0v 2347.49n 0.0v 2347.51n 0.0v 2397.49n 0.0v 2397.51n 0.0v 2447.49n 0.0v 2447.51n 0.0v 2497.49n 0.0v 2497.51n 0.0v 2547.49n 0.0v 2547.51n 0.0v 2597.49n 0.0v 2597.51n 0.0v 2647.49n 0.0v 2647.51n 0.0v 2697.49n 0.0v 2697.51n 0.0v 2747.49n 0.0v 2747.51n 0.0v 2797.49n 0.0v 2797.51n 1.8v 2847.49n 1.8v 2847.51n 1.8v 2897.49n 1.8v 2897.51n 1.8v 2947.49n 1.8v 2947.51n 1.8v 2997.49n 1.8v 2997.51n 1.8v 3047.49n 1.8v 3047.51n 1.8v 3097.49n 1.8v 3097.51n 1.8v 3147.49n 1.8v 3147.51n 1.8v 3197.49n 1.8v 3197.51n 1.8v 3247.49n 1.8v 3247.51n 1.8v 3297.49n 1.8v 3297.51n 1.8v 3347.49n 1.8v 3347.51n 1.8v 3397.49n 1.8v 3397.51n 1.8v 3447.49n 1.8v 3447.51n 1.8v 3497.49n 1.8v 3497.51n 1.8v 3547.49n 1.8v 3547.51n 1.8v 3597.49n 1.8v 3597.51n 1.8v 3647.49n 1.8v 3647.51n 0.0v 3697.49n 0.0v 3697.51n 0.0v 3747.49n 0.0v 3747.51n 0.0v 3797.49n 0.0v 3797.51n 0.0v 3847.49n 0.0v 3847.51n 0.0v 3897.49n 0.0v 3897.51n 0.0v 3947.49n 0.0v 3947.51n 0.0v 3997.49n 0.0v 3997.51n 0.0v 4047.49n 0.0v 4047.51n 0.0v 4097.49n 0.0v 4097.51n 0.0v 4147.49n 0.0v 4147.51n 0.0v 4197.49n 0.0v 4197.51n 0.0v 4247.49n 0.0v 4247.51n 0.0v 4297.49n 0.0v 4297.51n 0.0v 4347.49n 0.0v 4347.51n 0.0v 4397.49n 0.0v 4397.51n 0.0v 4447.49n 0.0v 4447.51n 0.0v 4497.49n 0.0v 4497.51n 1.8v 4547.49n 1.8v 4547.51n 1.8v 4597.49n 1.8v 4597.51n 1.8v 4647.49n 1.8v 4647.51n 1.8v 4697.49n 1.8v 4697.51n 1.8v 4747.49n 1.8v 4747.51n 0.0v 4797.49n 0.0v 4797.51n 0.0v 4847.49n 0.0v 4847.51n 0.0v 4897.49n 0.0v 4897.51n 1.8v 4947.49n 1.8v 4947.51n 1.8v 4997.49n 1.8v 4997.51n 1.8v 5047.49n 1.8v 5047.51n 1.8v 5097.49n 1.8v 5097.51n 1.8v 5147.49n 1.8v 5147.51n 1.8v 5197.49n 1.8v 5197.51n 1.8v 5247.49n 1.8v 5247.51n 1.8v 5297.49n 1.8v 5297.51n 0.0v 5347.49n 0.0v 5347.51n 0.0v 5397.49n 0.0v 5397.51n 0.0v 5447.49n 0.0v 5447.51n 0.0v 5497.49n 0.0v 5497.51n 1.8v 5547.49n 1.8v 5547.51n 1.8v 5597.49n 1.8v 5597.51n 1.8v 5647.49n 1.8v 5647.51n 1.8v 5697.49n 1.8v 5697.51n 1.8v 5747.49n 1.8v 5747.51n 1.8v 5797.49n 1.8v 5797.51n 1.8v 5847.49n 1.8v 5847.51n 1.8v 5897.49n 1.8v 5897.51n 1.8v 5947.49n 1.8v 5947.51n 0.0v 5997.49n 0.0v 5997.51n 1.8v 6047.49n 1.8v 6047.51n 1.8v 6097.49n 1.8v 6097.51n 0.0v 6147.49n 0.0v 6147.51n 0.0v 6197.49n 0.0v 6197.51n 0.0v 6247.49n 0.0v 6247.51n 0.0v 6297.49n 0.0v 6297.51n 0.0v 6347.49n 0.0v 6347.51n 1.8v 6397.49n 1.8v 6397.51n 1.8v 6447.49n 1.8v 6447.51n 1.8v 6497.49n 1.8v 6497.51n 1.8v 6547.49n 1.8v 6547.51n 1.8v 6597.49n 1.8v 6597.51n 0.0v 6647.49n 0.0v 6647.51n 0.0v 6697.49n 0.0v 6697.51n 0.0v 6747.49n 0.0v 6747.51n 0.0v 6797.49n 0.0v 6797.51n 0.0v 6847.49n 0.0v 6847.51n 0.0v 6897.49n 0.0v 6897.51n 0.0v 6947.49n 0.0v 6947.51n 0.0v 6997.49n 0.0v 6997.51n 0.0v 7047.49n 0.0v 7047.51n 0.0v 7097.49n 0.0v 7097.51n 0.0v 7147.49n 0.0v 7147.51n 0.0v 7197.49n 0.0v 7197.51n 1.8v 7247.49n 1.8v 7247.51n 1.8v 7297.49n 1.8v 7297.51n 1.8v 7347.49n 1.8v 7347.51n 1.8v 7397.49n 1.8v 7397.51n 1.8v 7447.49n 1.8v 7447.51n 1.8v 7497.49n 1.8v 7497.51n 0.0v 7547.49n 0.0v 7547.51n 0.0v 7597.49n 0.0v 7597.51n 0.0v 7647.49n 0.0v 7647.51n 0.0v 7697.49n 0.0v 7697.51n 1.8v 7747.49n 1.8v 7747.51n 1.8v 7797.49n 1.8v 7797.51n 1.8v 7847.49n 1.8v 7847.51n 0.0v 7897.49n 0.0v 7897.51n 0.0v 7947.49n 0.0v 7947.51n 1.8v 7997.49n 1.8v 7997.51n 1.8v 8047.49n 1.8v 8047.51n 1.8v 8097.49n 1.8v 8097.51n 1.8v 8147.49n 1.8v 8147.51n 1.8v 8197.49n 1.8v 8197.51n 1.8v 8247.49n 1.8v 8247.51n 1.8v 8297.49n 1.8v 8297.51n 1.8v 8347.49n 1.8v 8347.51n 1.8v 8397.49n 1.8v 8397.51n 1.8v 8447.49n 1.8v 8447.51n 0.0v 8497.49n 0.0v 8497.51n 0.0v 8547.49n 0.0v 8547.51n 0.0v 8597.49n 0.0v 8597.51n 0.0v 8647.49n 0.0v 8647.51n 0.0v 8697.49n 0.0v 8697.51n 0.0v 8747.49n 0.0v 8747.51n 0.0v 8797.49n 0.0v 8797.51n 0.0v 8847.49n 0.0v 8847.51n 0.0v 8897.49n 0.0v 8897.51n 1.8v 8947.49n 1.8v 8947.51n 1.8v 8997.49n 1.8v 8997.51n 0.0v 9047.49n 0.0v 9047.51n 0.0v 9097.49n 0.0v 9097.51n 0.0v 9147.49n 0.0v 9147.51n 0.0v 9197.49n 0.0v 9197.51n 0.0v 9247.49n 0.0v 9247.51n 0.0v 9297.49n 0.0v 9297.51n 0.0v 9347.49n 0.0v 9347.51n 0.0v 9397.49n 0.0v 9397.51n 0.0v 9447.49n 0.0v 9447.51n 0.0v 9497.49n 0.0v 9497.51n 0.0v 9547.49n 0.0v 9547.51n 0.0v 9597.49n 0.0v 9597.51n 0.0v 9647.49n 0.0v 9647.51n 0.0v 9697.49n 0.0v 9697.51n 0.0v 9747.49n 0.0v 9747.51n 0.0v 9797.49n 0.0v 9797.51n 0.0v 9847.49n 0.0v 9847.51n 0.0v 9897.49n 0.0v 9897.51n 0.0v 9947.49n 0.0v 9947.51n 0.0v 9997.49n 0.0v 9997.51n 1.8v 10047.49n 1.8v 10047.51n 1.8v 10097.49n 1.8v 10097.51n 1.8v 10147.49n 1.8v 10147.51n 0.0v 10197.49n 0.0v 10197.51n 0.0v 10247.49n 0.0v 10247.51n 0.0v )
* (time, data): [(0, 0), (50, 0), (100, 1), (150, 1), (200, 1), (250, 1), (300, 1), (350, 1), (400, 1), (450, 0), (500, 0), (550, 0), (600, 0), (650, 1), (700, 1), (750, 1), (800, 1), (850, 1), (900, 1), (950, 1), (1000, 1), (1050, 1), (1100, 1), (1150, 0), (1200, 0), (1250, 0), (1300, 0), (1350, 0), (1400, 0), (1450, 0), (1500, 1), (1550, 1), (1600, 1), (1650, 1), (1700, 1), (1750, 1), (1800, 1), (1850, 1), (1900, 1), (1950, 1), (2000, 1), (2050, 1), (2100, 1), (2150, 1), (2200, 1), (2250, 0), (2300, 0), (2350, 0), (2400, 0), (2450, 0), (2500, 0), (2550, 0), (2600, 0), (2650, 0), (2700, 0), (2750, 0), (2800, 0), (2850, 1), (2900, 1), (2950, 1), (3000, 1), (3050, 1), (3100, 0), (3150, 0), (3200, 1), (3250, 1), (3300, 1), (3350, 1), (3400, 1), (3450, 0), (3500, 0), (3550, 0), (3600, 0), (3650, 1), (3700, 1), (3750, 1), (3800, 1), (3850, 1), (3900, 1), (3950, 1), (4000, 1), (4050, 1), (4100, 1), (4150, 1), (4200, 1), (4250, 1), (4300, 1), (4350, 1), (4400, 1), (4450, 1), (4500, 1), (4550, 1), (4600, 1), (4650, 1), (4700, 1), (4750, 0), (4800, 1), (4850, 1), (4900, 0), (4950, 0), (5000, 0), (5050, 0), (5100, 0), (5150, 0), (5200, 0), (5250, 0), (5300, 1), (5350, 1), (5400, 1), (5450, 1), (5500, 0), (5550, 0), (5600, 1), (5650, 1), (5700, 1), (5750, 1), (5800, 1), (5850, 1), (5900, 1), (5950, 1), (6000, 0), (6050, 0), (6100, 0), (6150, 0), (6200, 0), (6250, 0), (6300, 0), (6350, 1), (6400, 1), (6450, 1), (6500, 1), (6550, 1), (6600, 1), (6650, 1), (6700, 1), (6750, 1), (6800, 1), (6850, 1), (6900, 1), (6950, 1), (7000, 1), (7050, 1), (7100, 1), (7150, 1), (7200, 0), (7250, 0), (7300, 0), (7350, 0), (7400, 0), (7450, 0), (7500, 1), (7550, 1), (7600, 1), (7650, 1), (7700, 1), (7750, 1), (7800, 0), (7850, 0), (7900, 0), (7950, 0), (8000, 0), (8050, 0), (8100, 0), (8150, 0), (8200, 0), (8250, 0), (8300, 0), (8350, 0), (8400, 0), (8450, 1), (8500, 1), (8550, 1), (8600, 1), (8650, 1), (8700, 1), (8750, 0), (8800, 0), (8850, 0), (8900, 0), (8950, 0), (9000, 1), (9050, 0), (9100, 0), (9150, 0), (9200, 0), (9250, 0), (9300, 0), (9350, 0), (9400, 0), (9450, 0), (9500, 0), (9550, 0), (9600, 1), (9650, 1), (9700, 1), (9750, 1), (9800, 1), (9850, 1), (9900, 1), (9950, 1), (10000, 1), (10050, 1), (10100, 1), (10150, 0), (10200, 0), (10250, 0)]
Vdin0_6  din0_6  0 PWL (0n 0.0v 47.49n 0.0v 47.51n 0.0v 97.49n 0.0v 97.51n 1.8v 147.49n 1.8v 147.51n 1.8v 197.49n 1.8v 197.51n 1.8v 247.49n 1.8v 247.51n 1.8v 297.49n 1.8v 297.51n 1.8v 347.49n 1.8v 347.51n 1.8v 397.49n 1.8v 397.51n 1.8v 447.49n 1.8v 447.51n 0.0v 497.49n 0.0v 497.51n 0.0v 547.49n 0.0v 547.51n 0.0v 597.49n 0.0v 597.51n 0.0v 647.49n 0.0v 647.51n 1.8v 697.49n 1.8v 697.51n 1.8v 747.49n 1.8v 747.51n 1.8v 797.49n 1.8v 797.51n 1.8v 847.49n 1.8v 847.51n 1.8v 897.49n 1.8v 897.51n 1.8v 947.49n 1.8v 947.51n 1.8v 997.49n 1.8v 997.51n 1.8v 1047.49n 1.8v 1047.51n 1.8v 1097.49n 1.8v 1097.51n 1.8v 1147.49n 1.8v 1147.51n 0.0v 1197.49n 0.0v 1197.51n 0.0v 1247.49n 0.0v 1247.51n 0.0v 1297.49n 0.0v 1297.51n 0.0v 1347.49n 0.0v 1347.51n 0.0v 1397.49n 0.0v 1397.51n 0.0v 1447.49n 0.0v 1447.51n 0.0v 1497.49n 0.0v 1497.51n 1.8v 1547.49n 1.8v 1547.51n 1.8v 1597.49n 1.8v 1597.51n 1.8v 1647.49n 1.8v 1647.51n 1.8v 1697.49n 1.8v 1697.51n 1.8v 1747.49n 1.8v 1747.51n 1.8v 1797.49n 1.8v 1797.51n 1.8v 1847.49n 1.8v 1847.51n 1.8v 1897.49n 1.8v 1897.51n 1.8v 1947.49n 1.8v 1947.51n 1.8v 1997.49n 1.8v 1997.51n 1.8v 2047.49n 1.8v 2047.51n 1.8v 2097.49n 1.8v 2097.51n 1.8v 2147.49n 1.8v 2147.51n 1.8v 2197.49n 1.8v 2197.51n 1.8v 2247.49n 1.8v 2247.51n 0.0v 2297.49n 0.0v 2297.51n 0.0v 2347.49n 0.0v 2347.51n 0.0v 2397.49n 0.0v 2397.51n 0.0v 2447.49n 0.0v 2447.51n 0.0v 2497.49n 0.0v 2497.51n 0.0v 2547.49n 0.0v 2547.51n 0.0v 2597.49n 0.0v 2597.51n 0.0v 2647.49n 0.0v 2647.51n 0.0v 2697.49n 0.0v 2697.51n 0.0v 2747.49n 0.0v 2747.51n 0.0v 2797.49n 0.0v 2797.51n 0.0v 2847.49n 0.0v 2847.51n 1.8v 2897.49n 1.8v 2897.51n 1.8v 2947.49n 1.8v 2947.51n 1.8v 2997.49n 1.8v 2997.51n 1.8v 3047.49n 1.8v 3047.51n 1.8v 3097.49n 1.8v 3097.51n 0.0v 3147.49n 0.0v 3147.51n 0.0v 3197.49n 0.0v 3197.51n 1.8v 3247.49n 1.8v 3247.51n 1.8v 3297.49n 1.8v 3297.51n 1.8v 3347.49n 1.8v 3347.51n 1.8v 3397.49n 1.8v 3397.51n 1.8v 3447.49n 1.8v 3447.51n 0.0v 3497.49n 0.0v 3497.51n 0.0v 3547.49n 0.0v 3547.51n 0.0v 3597.49n 0.0v 3597.51n 0.0v 3647.49n 0.0v 3647.51n 1.8v 3697.49n 1.8v 3697.51n 1.8v 3747.49n 1.8v 3747.51n 1.8v 3797.49n 1.8v 3797.51n 1.8v 3847.49n 1.8v 3847.51n 1.8v 3897.49n 1.8v 3897.51n 1.8v 3947.49n 1.8v 3947.51n 1.8v 3997.49n 1.8v 3997.51n 1.8v 4047.49n 1.8v 4047.51n 1.8v 4097.49n 1.8v 4097.51n 1.8v 4147.49n 1.8v 4147.51n 1.8v 4197.49n 1.8v 4197.51n 1.8v 4247.49n 1.8v 4247.51n 1.8v 4297.49n 1.8v 4297.51n 1.8v 4347.49n 1.8v 4347.51n 1.8v 4397.49n 1.8v 4397.51n 1.8v 4447.49n 1.8v 4447.51n 1.8v 4497.49n 1.8v 4497.51n 1.8v 4547.49n 1.8v 4547.51n 1.8v 4597.49n 1.8v 4597.51n 1.8v 4647.49n 1.8v 4647.51n 1.8v 4697.49n 1.8v 4697.51n 1.8v 4747.49n 1.8v 4747.51n 0.0v 4797.49n 0.0v 4797.51n 1.8v 4847.49n 1.8v 4847.51n 1.8v 4897.49n 1.8v 4897.51n 0.0v 4947.49n 0.0v 4947.51n 0.0v 4997.49n 0.0v 4997.51n 0.0v 5047.49n 0.0v 5047.51n 0.0v 5097.49n 0.0v 5097.51n 0.0v 5147.49n 0.0v 5147.51n 0.0v 5197.49n 0.0v 5197.51n 0.0v 5247.49n 0.0v 5247.51n 0.0v 5297.49n 0.0v 5297.51n 1.8v 5347.49n 1.8v 5347.51n 1.8v 5397.49n 1.8v 5397.51n 1.8v 5447.49n 1.8v 5447.51n 1.8v 5497.49n 1.8v 5497.51n 0.0v 5547.49n 0.0v 5547.51n 0.0v 5597.49n 0.0v 5597.51n 1.8v 5647.49n 1.8v 5647.51n 1.8v 5697.49n 1.8v 5697.51n 1.8v 5747.49n 1.8v 5747.51n 1.8v 5797.49n 1.8v 5797.51n 1.8v 5847.49n 1.8v 5847.51n 1.8v 5897.49n 1.8v 5897.51n 1.8v 5947.49n 1.8v 5947.51n 1.8v 5997.49n 1.8v 5997.51n 0.0v 6047.49n 0.0v 6047.51n 0.0v 6097.49n 0.0v 6097.51n 0.0v 6147.49n 0.0v 6147.51n 0.0v 6197.49n 0.0v 6197.51n 0.0v 6247.49n 0.0v 6247.51n 0.0v 6297.49n 0.0v 6297.51n 0.0v 6347.49n 0.0v 6347.51n 1.8v 6397.49n 1.8v 6397.51n 1.8v 6447.49n 1.8v 6447.51n 1.8v 6497.49n 1.8v 6497.51n 1.8v 6547.49n 1.8v 6547.51n 1.8v 6597.49n 1.8v 6597.51n 1.8v 6647.49n 1.8v 6647.51n 1.8v 6697.49n 1.8v 6697.51n 1.8v 6747.49n 1.8v 6747.51n 1.8v 6797.49n 1.8v 6797.51n 1.8v 6847.49n 1.8v 6847.51n 1.8v 6897.49n 1.8v 6897.51n 1.8v 6947.49n 1.8v 6947.51n 1.8v 6997.49n 1.8v 6997.51n 1.8v 7047.49n 1.8v 7047.51n 1.8v 7097.49n 1.8v 7097.51n 1.8v 7147.49n 1.8v 7147.51n 1.8v 7197.49n 1.8v 7197.51n 0.0v 7247.49n 0.0v 7247.51n 0.0v 7297.49n 0.0v 7297.51n 0.0v 7347.49n 0.0v 7347.51n 0.0v 7397.49n 0.0v 7397.51n 0.0v 7447.49n 0.0v 7447.51n 0.0v 7497.49n 0.0v 7497.51n 1.8v 7547.49n 1.8v 7547.51n 1.8v 7597.49n 1.8v 7597.51n 1.8v 7647.49n 1.8v 7647.51n 1.8v 7697.49n 1.8v 7697.51n 1.8v 7747.49n 1.8v 7747.51n 1.8v 7797.49n 1.8v 7797.51n 0.0v 7847.49n 0.0v 7847.51n 0.0v 7897.49n 0.0v 7897.51n 0.0v 7947.49n 0.0v 7947.51n 0.0v 7997.49n 0.0v 7997.51n 0.0v 8047.49n 0.0v 8047.51n 0.0v 8097.49n 0.0v 8097.51n 0.0v 8147.49n 0.0v 8147.51n 0.0v 8197.49n 0.0v 8197.51n 0.0v 8247.49n 0.0v 8247.51n 0.0v 8297.49n 0.0v 8297.51n 0.0v 8347.49n 0.0v 8347.51n 0.0v 8397.49n 0.0v 8397.51n 0.0v 8447.49n 0.0v 8447.51n 1.8v 8497.49n 1.8v 8497.51n 1.8v 8547.49n 1.8v 8547.51n 1.8v 8597.49n 1.8v 8597.51n 1.8v 8647.49n 1.8v 8647.51n 1.8v 8697.49n 1.8v 8697.51n 1.8v 8747.49n 1.8v 8747.51n 0.0v 8797.49n 0.0v 8797.51n 0.0v 8847.49n 0.0v 8847.51n 0.0v 8897.49n 0.0v 8897.51n 0.0v 8947.49n 0.0v 8947.51n 0.0v 8997.49n 0.0v 8997.51n 1.8v 9047.49n 1.8v 9047.51n 0.0v 9097.49n 0.0v 9097.51n 0.0v 9147.49n 0.0v 9147.51n 0.0v 9197.49n 0.0v 9197.51n 0.0v 9247.49n 0.0v 9247.51n 0.0v 9297.49n 0.0v 9297.51n 0.0v 9347.49n 0.0v 9347.51n 0.0v 9397.49n 0.0v 9397.51n 0.0v 9447.49n 0.0v 9447.51n 0.0v 9497.49n 0.0v 9497.51n 0.0v 9547.49n 0.0v 9547.51n 0.0v 9597.49n 0.0v 9597.51n 1.8v 9647.49n 1.8v 9647.51n 1.8v 9697.49n 1.8v 9697.51n 1.8v 9747.49n 1.8v 9747.51n 1.8v 9797.49n 1.8v 9797.51n 1.8v 9847.49n 1.8v 9847.51n 1.8v 9897.49n 1.8v 9897.51n 1.8v 9947.49n 1.8v 9947.51n 1.8v 9997.49n 1.8v 9997.51n 1.8v 10047.49n 1.8v 10047.51n 1.8v 10097.49n 1.8v 10097.51n 1.8v 10147.49n 1.8v 10147.51n 0.0v 10197.49n 0.0v 10197.51n 0.0v 10247.49n 0.0v 10247.51n 0.0v )
* (time, data): [(0, 0), (50, 1), (100, 0), (150, 0), (200, 0), (250, 0), (300, 0), (350, 1), (400, 1), (450, 1), (500, 1), (550, 1), (600, 1), (650, 1), (700, 1), (750, 1), (800, 1), (850, 1), (900, 1), (950, 1), (1000, 1), (1050, 1), (1100, 1), (1150, 1), (1200, 1), (1250, 1), (1300, 1), (1350, 1), (1400, 1), (1450, 1), (1500, 1), (1550, 1), (1600, 0), (1650, 0), (1700, 0), (1750, 0), (1800, 1), (1850, 1), (1900, 1), (1950, 1), (2000, 1), (2050, 1), (2100, 1), (2150, 1), (2200, 1), (2250, 0), (2300, 0), (2350, 0), (2400, 0), (2450, 0), (2500, 0), (2550, 0), (2600, 0), (2650, 0), (2700, 0), (2750, 0), (2800, 0), (2850, 0), (2900, 0), (2950, 0), (3000, 0), (3050, 0), (3100, 0), (3150, 0), (3200, 0), (3250, 0), (3300, 0), (3350, 0), (3400, 0), (3450, 1), (3500, 1), (3550, 1), (3600, 1), (3650, 0), (3700, 0), (3750, 0), (3800, 0), (3850, 0), (3900, 0), (3950, 0), (4000, 0), (4050, 0), (4100, 0), (4150, 0), (4200, 0), (4250, 0), (4300, 0), (4350, 0), (4400, 0), (4450, 0), (4500, 0), (4550, 0), (4600, 0), (4650, 0), (4700, 0), (4750, 1), (4800, 1), (4850, 1), (4900, 0), (4950, 0), (5000, 0), (5050, 0), (5100, 0), (5150, 0), (5200, 0), (5250, 0), (5300, 0), (5350, 0), (5400, 0), (5450, 0), (5500, 1), (5550, 1), (5600, 0), (5650, 0), (5700, 0), (5750, 0), (5800, 0), (5850, 0), (5900, 0), (5950, 0), (6000, 1), (6050, 1), (6100, 0), (6150, 0), (6200, 0), (6250, 0), (6300, 0), (6350, 0), (6400, 0), (6450, 0), (6500, 0), (6550, 0), (6600, 1), (6650, 1), (6700, 1), (6750, 1), (6800, 1), (6850, 1), (6900, 1), (6950, 1), (7000, 1), (7050, 1), (7100, 1), (7150, 1), (7200, 0), (7250, 0), (7300, 0), (7350, 0), (7400, 0), (7450, 0), (7500, 1), (7550, 1), (7600, 1), (7650, 1), (7700, 0), (7750, 0), (7800, 1), (7850, 0), (7900, 0), (7950, 0), (8000, 0), (8050, 1), (8100, 1), (8150, 0), (8200, 0), (8250, 0), (8300, 0), (8350, 0), (8400, 0), (8450, 0), (8500, 0), (8550, 0), (8600, 0), (8650, 0), (8700, 0), (8750, 0), (8800, 0), (8850, 0), (8900, 0), (8950, 0), (9000, 1), (9050, 0), (9100, 0), (9150, 0), (9200, 0), (9250, 0), (9300, 0), (9350, 0), (9400, 1), (9450, 1), (9500, 1), (9550, 1), (9600, 0), (9650, 0), (9700, 0), (9750, 0), (9800, 0), (9850, 0), (9900, 0), (9950, 0), (10000, 1), (10050, 1), (10100, 1), (10150, 0), (10200, 0), (10250, 0)]
Vdin0_7  din0_7  0 PWL (0n 0.0v 47.49n 0.0v 47.51n 1.8v 97.49n 1.8v 97.51n 0.0v 147.49n 0.0v 147.51n 0.0v 197.49n 0.0v 197.51n 0.0v 247.49n 0.0v 247.51n 0.0v 297.49n 0.0v 297.51n 0.0v 347.49n 0.0v 347.51n 1.8v 397.49n 1.8v 397.51n 1.8v 447.49n 1.8v 447.51n 1.8v 497.49n 1.8v 497.51n 1.8v 547.49n 1.8v 547.51n 1.8v 597.49n 1.8v 597.51n 1.8v 647.49n 1.8v 647.51n 1.8v 697.49n 1.8v 697.51n 1.8v 747.49n 1.8v 747.51n 1.8v 797.49n 1.8v 797.51n 1.8v 847.49n 1.8v 847.51n 1.8v 897.49n 1.8v 897.51n 1.8v 947.49n 1.8v 947.51n 1.8v 997.49n 1.8v 997.51n 1.8v 1047.49n 1.8v 1047.51n 1.8v 1097.49n 1.8v 1097.51n 1.8v 1147.49n 1.8v 1147.51n 1.8v 1197.49n 1.8v 1197.51n 1.8v 1247.49n 1.8v 1247.51n 1.8v 1297.49n 1.8v 1297.51n 1.8v 1347.49n 1.8v 1347.51n 1.8v 1397.49n 1.8v 1397.51n 1.8v 1447.49n 1.8v 1447.51n 1.8v 1497.49n 1.8v 1497.51n 1.8v 1547.49n 1.8v 1547.51n 1.8v 1597.49n 1.8v 1597.51n 0.0v 1647.49n 0.0v 1647.51n 0.0v 1697.49n 0.0v 1697.51n 0.0v 1747.49n 0.0v 1747.51n 0.0v 1797.49n 0.0v 1797.51n 1.8v 1847.49n 1.8v 1847.51n 1.8v 1897.49n 1.8v 1897.51n 1.8v 1947.49n 1.8v 1947.51n 1.8v 1997.49n 1.8v 1997.51n 1.8v 2047.49n 1.8v 2047.51n 1.8v 2097.49n 1.8v 2097.51n 1.8v 2147.49n 1.8v 2147.51n 1.8v 2197.49n 1.8v 2197.51n 1.8v 2247.49n 1.8v 2247.51n 0.0v 2297.49n 0.0v 2297.51n 0.0v 2347.49n 0.0v 2347.51n 0.0v 2397.49n 0.0v 2397.51n 0.0v 2447.49n 0.0v 2447.51n 0.0v 2497.49n 0.0v 2497.51n 0.0v 2547.49n 0.0v 2547.51n 0.0v 2597.49n 0.0v 2597.51n 0.0v 2647.49n 0.0v 2647.51n 0.0v 2697.49n 0.0v 2697.51n 0.0v 2747.49n 0.0v 2747.51n 0.0v 2797.49n 0.0v 2797.51n 0.0v 2847.49n 0.0v 2847.51n 0.0v 2897.49n 0.0v 2897.51n 0.0v 2947.49n 0.0v 2947.51n 0.0v 2997.49n 0.0v 2997.51n 0.0v 3047.49n 0.0v 3047.51n 0.0v 3097.49n 0.0v 3097.51n 0.0v 3147.49n 0.0v 3147.51n 0.0v 3197.49n 0.0v 3197.51n 0.0v 3247.49n 0.0v 3247.51n 0.0v 3297.49n 0.0v 3297.51n 0.0v 3347.49n 0.0v 3347.51n 0.0v 3397.49n 0.0v 3397.51n 0.0v 3447.49n 0.0v 3447.51n 1.8v 3497.49n 1.8v 3497.51n 1.8v 3547.49n 1.8v 3547.51n 1.8v 3597.49n 1.8v 3597.51n 1.8v 3647.49n 1.8v 3647.51n 0.0v 3697.49n 0.0v 3697.51n 0.0v 3747.49n 0.0v 3747.51n 0.0v 3797.49n 0.0v 3797.51n 0.0v 3847.49n 0.0v 3847.51n 0.0v 3897.49n 0.0v 3897.51n 0.0v 3947.49n 0.0v 3947.51n 0.0v 3997.49n 0.0v 3997.51n 0.0v 4047.49n 0.0v 4047.51n 0.0v 4097.49n 0.0v 4097.51n 0.0v 4147.49n 0.0v 4147.51n 0.0v 4197.49n 0.0v 4197.51n 0.0v 4247.49n 0.0v 4247.51n 0.0v 4297.49n 0.0v 4297.51n 0.0v 4347.49n 0.0v 4347.51n 0.0v 4397.49n 0.0v 4397.51n 0.0v 4447.49n 0.0v 4447.51n 0.0v 4497.49n 0.0v 4497.51n 0.0v 4547.49n 0.0v 4547.51n 0.0v 4597.49n 0.0v 4597.51n 0.0v 4647.49n 0.0v 4647.51n 0.0v 4697.49n 0.0v 4697.51n 0.0v 4747.49n 0.0v 4747.51n 1.8v 4797.49n 1.8v 4797.51n 1.8v 4847.49n 1.8v 4847.51n 1.8v 4897.49n 1.8v 4897.51n 0.0v 4947.49n 0.0v 4947.51n 0.0v 4997.49n 0.0v 4997.51n 0.0v 5047.49n 0.0v 5047.51n 0.0v 5097.49n 0.0v 5097.51n 0.0v 5147.49n 0.0v 5147.51n 0.0v 5197.49n 0.0v 5197.51n 0.0v 5247.49n 0.0v 5247.51n 0.0v 5297.49n 0.0v 5297.51n 0.0v 5347.49n 0.0v 5347.51n 0.0v 5397.49n 0.0v 5397.51n 0.0v 5447.49n 0.0v 5447.51n 0.0v 5497.49n 0.0v 5497.51n 1.8v 5547.49n 1.8v 5547.51n 1.8v 5597.49n 1.8v 5597.51n 0.0v 5647.49n 0.0v 5647.51n 0.0v 5697.49n 0.0v 5697.51n 0.0v 5747.49n 0.0v 5747.51n 0.0v 5797.49n 0.0v 5797.51n 0.0v 5847.49n 0.0v 5847.51n 0.0v 5897.49n 0.0v 5897.51n 0.0v 5947.49n 0.0v 5947.51n 0.0v 5997.49n 0.0v 5997.51n 1.8v 6047.49n 1.8v 6047.51n 1.8v 6097.49n 1.8v 6097.51n 0.0v 6147.49n 0.0v 6147.51n 0.0v 6197.49n 0.0v 6197.51n 0.0v 6247.49n 0.0v 6247.51n 0.0v 6297.49n 0.0v 6297.51n 0.0v 6347.49n 0.0v 6347.51n 0.0v 6397.49n 0.0v 6397.51n 0.0v 6447.49n 0.0v 6447.51n 0.0v 6497.49n 0.0v 6497.51n 0.0v 6547.49n 0.0v 6547.51n 0.0v 6597.49n 0.0v 6597.51n 1.8v 6647.49n 1.8v 6647.51n 1.8v 6697.49n 1.8v 6697.51n 1.8v 6747.49n 1.8v 6747.51n 1.8v 6797.49n 1.8v 6797.51n 1.8v 6847.49n 1.8v 6847.51n 1.8v 6897.49n 1.8v 6897.51n 1.8v 6947.49n 1.8v 6947.51n 1.8v 6997.49n 1.8v 6997.51n 1.8v 7047.49n 1.8v 7047.51n 1.8v 7097.49n 1.8v 7097.51n 1.8v 7147.49n 1.8v 7147.51n 1.8v 7197.49n 1.8v 7197.51n 0.0v 7247.49n 0.0v 7247.51n 0.0v 7297.49n 0.0v 7297.51n 0.0v 7347.49n 0.0v 7347.51n 0.0v 7397.49n 0.0v 7397.51n 0.0v 7447.49n 0.0v 7447.51n 0.0v 7497.49n 0.0v 7497.51n 1.8v 7547.49n 1.8v 7547.51n 1.8v 7597.49n 1.8v 7597.51n 1.8v 7647.49n 1.8v 7647.51n 1.8v 7697.49n 1.8v 7697.51n 0.0v 7747.49n 0.0v 7747.51n 0.0v 7797.49n 0.0v 7797.51n 1.8v 7847.49n 1.8v 7847.51n 0.0v 7897.49n 0.0v 7897.51n 0.0v 7947.49n 0.0v 7947.51n 0.0v 7997.49n 0.0v 7997.51n 0.0v 8047.49n 0.0v 8047.51n 1.8v 8097.49n 1.8v 8097.51n 1.8v 8147.49n 1.8v 8147.51n 0.0v 8197.49n 0.0v 8197.51n 0.0v 8247.49n 0.0v 8247.51n 0.0v 8297.49n 0.0v 8297.51n 0.0v 8347.49n 0.0v 8347.51n 0.0v 8397.49n 0.0v 8397.51n 0.0v 8447.49n 0.0v 8447.51n 0.0v 8497.49n 0.0v 8497.51n 0.0v 8547.49n 0.0v 8547.51n 0.0v 8597.49n 0.0v 8597.51n 0.0v 8647.49n 0.0v 8647.51n 0.0v 8697.49n 0.0v 8697.51n 0.0v 8747.49n 0.0v 8747.51n 0.0v 8797.49n 0.0v 8797.51n 0.0v 8847.49n 0.0v 8847.51n 0.0v 8897.49n 0.0v 8897.51n 0.0v 8947.49n 0.0v 8947.51n 0.0v 8997.49n 0.0v 8997.51n 1.8v 9047.49n 1.8v 9047.51n 0.0v 9097.49n 0.0v 9097.51n 0.0v 9147.49n 0.0v 9147.51n 0.0v 9197.49n 0.0v 9197.51n 0.0v 9247.49n 0.0v 9247.51n 0.0v 9297.49n 0.0v 9297.51n 0.0v 9347.49n 0.0v 9347.51n 0.0v 9397.49n 0.0v 9397.51n 1.8v 9447.49n 1.8v 9447.51n 1.8v 9497.49n 1.8v 9497.51n 1.8v 9547.49n 1.8v 9547.51n 1.8v 9597.49n 1.8v 9597.51n 0.0v 9647.49n 0.0v 9647.51n 0.0v 9697.49n 0.0v 9697.51n 0.0v 9747.49n 0.0v 9747.51n 0.0v 9797.49n 0.0v 9797.51n 0.0v 9847.49n 0.0v 9847.51n 0.0v 9897.49n 0.0v 9897.51n 0.0v 9947.49n 0.0v 9947.51n 0.0v 9997.49n 0.0v 9997.51n 1.8v 10047.49n 1.8v 10047.51n 1.8v 10097.49n 1.8v 10097.51n 1.8v 10147.49n 1.8v 10147.51n 0.0v 10197.49n 0.0v 10197.51n 0.0v 10247.49n 0.0v 10247.51n 0.0v )
* (time, data): [(0, 0), (50, 0), (100, 0), (150, 0), (200, 0), (250, 0), (300, 0), (350, 1), (400, 1), (450, 0), (500, 0), (550, 0), (600, 0), (650, 0), (700, 0), (750, 0), (800, 0), (850, 0), (900, 0), (950, 0), (1000, 0), (1050, 1), (1100, 1), (1150, 0), (1200, 0), (1250, 0), (1300, 0), (1350, 0), (1400, 0), (1450, 0), (1500, 0), (1550, 0), (1600, 1), (1650, 1), (1700, 1), (1750, 1), (1800, 0), (1850, 0), (1900, 0), (1950, 0), (2000, 0), (2050, 0), (2100, 0), (2150, 0), (2200, 0), (2250, 1), (2300, 1), (2350, 1), (2400, 1), (2450, 1), (2500, 1), (2550, 1), (2600, 1), (2650, 1), (2700, 1), (2750, 1), (2800, 1), (2850, 0), (2900, 0), (2950, 0), (3000, 0), (3050, 0), (3100, 1), (3150, 1), (3200, 0), (3250, 0), (3300, 0), (3350, 0), (3400, 0), (3450, 1), (3500, 1), (3550, 1), (3600, 1), (3650, 1), (3700, 1), (3750, 1), (3800, 1), (3850, 1), (3900, 1), (3950, 1), (4000, 1), (4050, 1), (4100, 0), (4150, 0), (4200, 0), (4250, 0), (4300, 0), (4350, 0), (4400, 0), (4450, 0), (4500, 1), (4550, 1), (4600, 1), (4650, 1), (4700, 1), (4750, 0), (4800, 1), (4850, 1), (4900, 1), (4950, 1), (5000, 1), (5050, 1), (5100, 1), (5150, 1), (5200, 1), (5250, 1), (5300, 0), (5350, 0), (5400, 0), (5450, 0), (5500, 1), (5550, 1), (5600, 0), (5650, 0), (5700, 0), (5750, 0), (5800, 0), (5850, 0), (5900, 0), (5950, 1), (6000, 1), (6050, 1), (6100, 0), (6150, 0), (6200, 0), (6250, 0), (6300, 0), (6350, 1), (6400, 1), (6450, 1), (6500, 1), (6550, 1), (6600, 0), (6650, 0), (6700, 0), (6750, 0), (6800, 0), (6850, 0), (6900, 0), (6950, 0), (7000, 0), (7050, 0), (7100, 0), (7150, 0), (7200, 0), (7250, 0), (7300, 0), (7350, 0), (7400, 0), (7450, 1), (7500, 0), (7550, 0), (7600, 0), (7650, 0), (7700, 0), (7750, 0), (7800, 0), (7850, 0), (7900, 0), (7950, 1), (8000, 1), (8050, 1), (8100, 1), (8150, 0), (8200, 0), (8250, 0), (8300, 0), (8350, 0), (8400, 0), (8450, 0), (8500, 0), (8550, 0), (8600, 0), (8650, 0), (8700, 0), (8750, 0), (8800, 0), (8850, 0), (8900, 1), (8950, 1), (9000, 1), (9050, 1), (9100, 1), (9150, 1), (9200, 1), (9250, 1), (9300, 1), (9350, 1), (9400, 0), (9450, 0), (9500, 0), (9550, 0), (9600, 1), (9650, 1), (9700, 1), (9750, 1), (9800, 1), (9850, 1), (9900, 1), (9950, 1), (10000, 1), (10050, 1), (10100, 1), (10150, 1), (10200, 1), (10250, 1)]
Vdin0_8  din0_8  0 PWL (0n 0.0v 47.49n 0.0v 47.51n 0.0v 97.49n 0.0v 97.51n 0.0v 147.49n 0.0v 147.51n 0.0v 197.49n 0.0v 197.51n 0.0v 247.49n 0.0v 247.51n 0.0v 297.49n 0.0v 297.51n 0.0v 347.49n 0.0v 347.51n 1.8v 397.49n 1.8v 397.51n 1.8v 447.49n 1.8v 447.51n 0.0v 497.49n 0.0v 497.51n 0.0v 547.49n 0.0v 547.51n 0.0v 597.49n 0.0v 597.51n 0.0v 647.49n 0.0v 647.51n 0.0v 697.49n 0.0v 697.51n 0.0v 747.49n 0.0v 747.51n 0.0v 797.49n 0.0v 797.51n 0.0v 847.49n 0.0v 847.51n 0.0v 897.49n 0.0v 897.51n 0.0v 947.49n 0.0v 947.51n 0.0v 997.49n 0.0v 997.51n 0.0v 1047.49n 0.0v 1047.51n 1.8v 1097.49n 1.8v 1097.51n 1.8v 1147.49n 1.8v 1147.51n 0.0v 1197.49n 0.0v 1197.51n 0.0v 1247.49n 0.0v 1247.51n 0.0v 1297.49n 0.0v 1297.51n 0.0v 1347.49n 0.0v 1347.51n 0.0v 1397.49n 0.0v 1397.51n 0.0v 1447.49n 0.0v 1447.51n 0.0v 1497.49n 0.0v 1497.51n 0.0v 1547.49n 0.0v 1547.51n 0.0v 1597.49n 0.0v 1597.51n 1.8v 1647.49n 1.8v 1647.51n 1.8v 1697.49n 1.8v 1697.51n 1.8v 1747.49n 1.8v 1747.51n 1.8v 1797.49n 1.8v 1797.51n 0.0v 1847.49n 0.0v 1847.51n 0.0v 1897.49n 0.0v 1897.51n 0.0v 1947.49n 0.0v 1947.51n 0.0v 1997.49n 0.0v 1997.51n 0.0v 2047.49n 0.0v 2047.51n 0.0v 2097.49n 0.0v 2097.51n 0.0v 2147.49n 0.0v 2147.51n 0.0v 2197.49n 0.0v 2197.51n 0.0v 2247.49n 0.0v 2247.51n 1.8v 2297.49n 1.8v 2297.51n 1.8v 2347.49n 1.8v 2347.51n 1.8v 2397.49n 1.8v 2397.51n 1.8v 2447.49n 1.8v 2447.51n 1.8v 2497.49n 1.8v 2497.51n 1.8v 2547.49n 1.8v 2547.51n 1.8v 2597.49n 1.8v 2597.51n 1.8v 2647.49n 1.8v 2647.51n 1.8v 2697.49n 1.8v 2697.51n 1.8v 2747.49n 1.8v 2747.51n 1.8v 2797.49n 1.8v 2797.51n 1.8v 2847.49n 1.8v 2847.51n 0.0v 2897.49n 0.0v 2897.51n 0.0v 2947.49n 0.0v 2947.51n 0.0v 2997.49n 0.0v 2997.51n 0.0v 3047.49n 0.0v 3047.51n 0.0v 3097.49n 0.0v 3097.51n 1.8v 3147.49n 1.8v 3147.51n 1.8v 3197.49n 1.8v 3197.51n 0.0v 3247.49n 0.0v 3247.51n 0.0v 3297.49n 0.0v 3297.51n 0.0v 3347.49n 0.0v 3347.51n 0.0v 3397.49n 0.0v 3397.51n 0.0v 3447.49n 0.0v 3447.51n 1.8v 3497.49n 1.8v 3497.51n 1.8v 3547.49n 1.8v 3547.51n 1.8v 3597.49n 1.8v 3597.51n 1.8v 3647.49n 1.8v 3647.51n 1.8v 3697.49n 1.8v 3697.51n 1.8v 3747.49n 1.8v 3747.51n 1.8v 3797.49n 1.8v 3797.51n 1.8v 3847.49n 1.8v 3847.51n 1.8v 3897.49n 1.8v 3897.51n 1.8v 3947.49n 1.8v 3947.51n 1.8v 3997.49n 1.8v 3997.51n 1.8v 4047.49n 1.8v 4047.51n 1.8v 4097.49n 1.8v 4097.51n 0.0v 4147.49n 0.0v 4147.51n 0.0v 4197.49n 0.0v 4197.51n 0.0v 4247.49n 0.0v 4247.51n 0.0v 4297.49n 0.0v 4297.51n 0.0v 4347.49n 0.0v 4347.51n 0.0v 4397.49n 0.0v 4397.51n 0.0v 4447.49n 0.0v 4447.51n 0.0v 4497.49n 0.0v 4497.51n 1.8v 4547.49n 1.8v 4547.51n 1.8v 4597.49n 1.8v 4597.51n 1.8v 4647.49n 1.8v 4647.51n 1.8v 4697.49n 1.8v 4697.51n 1.8v 4747.49n 1.8v 4747.51n 0.0v 4797.49n 0.0v 4797.51n 1.8v 4847.49n 1.8v 4847.51n 1.8v 4897.49n 1.8v 4897.51n 1.8v 4947.49n 1.8v 4947.51n 1.8v 4997.49n 1.8v 4997.51n 1.8v 5047.49n 1.8v 5047.51n 1.8v 5097.49n 1.8v 5097.51n 1.8v 5147.49n 1.8v 5147.51n 1.8v 5197.49n 1.8v 5197.51n 1.8v 5247.49n 1.8v 5247.51n 1.8v 5297.49n 1.8v 5297.51n 0.0v 5347.49n 0.0v 5347.51n 0.0v 5397.49n 0.0v 5397.51n 0.0v 5447.49n 0.0v 5447.51n 0.0v 5497.49n 0.0v 5497.51n 1.8v 5547.49n 1.8v 5547.51n 1.8v 5597.49n 1.8v 5597.51n 0.0v 5647.49n 0.0v 5647.51n 0.0v 5697.49n 0.0v 5697.51n 0.0v 5747.49n 0.0v 5747.51n 0.0v 5797.49n 0.0v 5797.51n 0.0v 5847.49n 0.0v 5847.51n 0.0v 5897.49n 0.0v 5897.51n 0.0v 5947.49n 0.0v 5947.51n 1.8v 5997.49n 1.8v 5997.51n 1.8v 6047.49n 1.8v 6047.51n 1.8v 6097.49n 1.8v 6097.51n 0.0v 6147.49n 0.0v 6147.51n 0.0v 6197.49n 0.0v 6197.51n 0.0v 6247.49n 0.0v 6247.51n 0.0v 6297.49n 0.0v 6297.51n 0.0v 6347.49n 0.0v 6347.51n 1.8v 6397.49n 1.8v 6397.51n 1.8v 6447.49n 1.8v 6447.51n 1.8v 6497.49n 1.8v 6497.51n 1.8v 6547.49n 1.8v 6547.51n 1.8v 6597.49n 1.8v 6597.51n 0.0v 6647.49n 0.0v 6647.51n 0.0v 6697.49n 0.0v 6697.51n 0.0v 6747.49n 0.0v 6747.51n 0.0v 6797.49n 0.0v 6797.51n 0.0v 6847.49n 0.0v 6847.51n 0.0v 6897.49n 0.0v 6897.51n 0.0v 6947.49n 0.0v 6947.51n 0.0v 6997.49n 0.0v 6997.51n 0.0v 7047.49n 0.0v 7047.51n 0.0v 7097.49n 0.0v 7097.51n 0.0v 7147.49n 0.0v 7147.51n 0.0v 7197.49n 0.0v 7197.51n 0.0v 7247.49n 0.0v 7247.51n 0.0v 7297.49n 0.0v 7297.51n 0.0v 7347.49n 0.0v 7347.51n 0.0v 7397.49n 0.0v 7397.51n 0.0v 7447.49n 0.0v 7447.51n 1.8v 7497.49n 1.8v 7497.51n 0.0v 7547.49n 0.0v 7547.51n 0.0v 7597.49n 0.0v 7597.51n 0.0v 7647.49n 0.0v 7647.51n 0.0v 7697.49n 0.0v 7697.51n 0.0v 7747.49n 0.0v 7747.51n 0.0v 7797.49n 0.0v 7797.51n 0.0v 7847.49n 0.0v 7847.51n 0.0v 7897.49n 0.0v 7897.51n 0.0v 7947.49n 0.0v 7947.51n 1.8v 7997.49n 1.8v 7997.51n 1.8v 8047.49n 1.8v 8047.51n 1.8v 8097.49n 1.8v 8097.51n 1.8v 8147.49n 1.8v 8147.51n 0.0v 8197.49n 0.0v 8197.51n 0.0v 8247.49n 0.0v 8247.51n 0.0v 8297.49n 0.0v 8297.51n 0.0v 8347.49n 0.0v 8347.51n 0.0v 8397.49n 0.0v 8397.51n 0.0v 8447.49n 0.0v 8447.51n 0.0v 8497.49n 0.0v 8497.51n 0.0v 8547.49n 0.0v 8547.51n 0.0v 8597.49n 0.0v 8597.51n 0.0v 8647.49n 0.0v 8647.51n 0.0v 8697.49n 0.0v 8697.51n 0.0v 8747.49n 0.0v 8747.51n 0.0v 8797.49n 0.0v 8797.51n 0.0v 8847.49n 0.0v 8847.51n 0.0v 8897.49n 0.0v 8897.51n 1.8v 8947.49n 1.8v 8947.51n 1.8v 8997.49n 1.8v 8997.51n 1.8v 9047.49n 1.8v 9047.51n 1.8v 9097.49n 1.8v 9097.51n 1.8v 9147.49n 1.8v 9147.51n 1.8v 9197.49n 1.8v 9197.51n 1.8v 9247.49n 1.8v 9247.51n 1.8v 9297.49n 1.8v 9297.51n 1.8v 9347.49n 1.8v 9347.51n 1.8v 9397.49n 1.8v 9397.51n 0.0v 9447.49n 0.0v 9447.51n 0.0v 9497.49n 0.0v 9497.51n 0.0v 9547.49n 0.0v 9547.51n 0.0v 9597.49n 0.0v 9597.51n 1.8v 9647.49n 1.8v 9647.51n 1.8v 9697.49n 1.8v 9697.51n 1.8v 9747.49n 1.8v 9747.51n 1.8v 9797.49n 1.8v 9797.51n 1.8v 9847.49n 1.8v 9847.51n 1.8v 9897.49n 1.8v 9897.51n 1.8v 9947.49n 1.8v 9947.51n 1.8v 9997.49n 1.8v 9997.51n 1.8v 10047.49n 1.8v 10047.51n 1.8v 10097.49n 1.8v 10097.51n 1.8v 10147.49n 1.8v 10147.51n 1.8v 10197.49n 1.8v 10197.51n 1.8v 10247.49n 1.8v 10247.51n 1.8v )
* (time, data): [(0, 0), (50, 0), (100, 0), (150, 0), (200, 0), (250, 0), (300, 0), (350, 0), (400, 0), (450, 0), (500, 0), (550, 0), (600, 0), (650, 1), (700, 1), (750, 1), (800, 1), (850, 1), (900, 1), (950, 1), (1000, 1), (1050, 1), (1100, 1), (1150, 1), (1200, 1), (1250, 1), (1300, 1), (1350, 1), (1400, 1), (1450, 1), (1500, 0), (1550, 0), (1600, 1), (1650, 1), (1700, 1), (1750, 1), (1800, 0), (1850, 0), (1900, 0), (1950, 0), (2000, 0), (2050, 0), (2100, 0), (2150, 0), (2200, 0), (2250, 1), (2300, 1), (2350, 1), (2400, 1), (2450, 1), (2500, 1), (2550, 1), (2600, 1), (2650, 1), (2700, 1), (2750, 1), (2800, 0), (2850, 0), (2900, 0), (2950, 0), (3000, 0), (3050, 0), (3100, 1), (3150, 1), (3200, 1), (3250, 1), (3300, 1), (3350, 1), (3400, 1), (3450, 1), (3500, 1), (3550, 1), (3600, 1), (3650, 1), (3700, 1), (3750, 1), (3800, 1), (3850, 1), (3900, 1), (3950, 1), (4000, 1), (4050, 1), (4100, 0), (4150, 0), (4200, 0), (4250, 0), (4300, 0), (4350, 0), (4400, 0), (4450, 0), (4500, 0), (4550, 0), (4600, 0), (4650, 0), (4700, 0), (4750, 1), (4800, 0), (4850, 0), (4900, 0), (4950, 0), (5000, 0), (5050, 0), (5100, 0), (5150, 0), (5200, 0), (5250, 0), (5300, 0), (5350, 0), (5400, 0), (5450, 0), (5500, 1), (5550, 1), (5600, 1), (5650, 1), (5700, 1), (5750, 1), (5800, 1), (5850, 1), (5900, 1), (5950, 1), (6000, 0), (6050, 0), (6100, 1), (6150, 1), (6200, 1), (6250, 1), (6300, 1), (6350, 1), (6400, 1), (6450, 1), (6500, 1), (6550, 1), (6600, 0), (6650, 0), (6700, 0), (6750, 0), (6800, 0), (6850, 0), (6900, 0), (6950, 0), (7000, 0), (7050, 0), (7100, 0), (7150, 0), (7200, 0), (7250, 0), (7300, 0), (7350, 0), (7400, 0), (7450, 1), (7500, 1), (7550, 1), (7600, 1), (7650, 1), (7700, 1), (7750, 1), (7800, 1), (7850, 0), (7900, 0), (7950, 0), (8000, 0), (8050, 0), (8100, 0), (8150, 0), (8200, 0), (8250, 0), (8300, 0), (8350, 0), (8400, 0), (8450, 1), (8500, 1), (8550, 1), (8600, 1), (8650, 1), (8700, 1), (8750, 0), (8800, 0), (8850, 0), (8900, 0), (8950, 0), (9000, 1), (9050, 0), (9100, 0), (9150, 0), (9200, 0), (9250, 0), (9300, 0), (9350, 0), (9400, 0), (9450, 0), (9500, 0), (9550, 0), (9600, 1), (9650, 1), (9700, 1), (9750, 1), (9800, 1), (9850, 1), (9900, 1), (9950, 1), (10000, 1), (10050, 1), (10100, 1), (10150, 1), (10200, 1), (10250, 1)]
Vdin0_9  din0_9  0 PWL (0n 0.0v 47.49n 0.0v 47.51n 0.0v 97.49n 0.0v 97.51n 0.0v 147.49n 0.0v 147.51n 0.0v 197.49n 0.0v 197.51n 0.0v 247.49n 0.0v 247.51n 0.0v 297.49n 0.0v 297.51n 0.0v 347.49n 0.0v 347.51n 0.0v 397.49n 0.0v 397.51n 0.0v 447.49n 0.0v 447.51n 0.0v 497.49n 0.0v 497.51n 0.0v 547.49n 0.0v 547.51n 0.0v 597.49n 0.0v 597.51n 0.0v 647.49n 0.0v 647.51n 1.8v 697.49n 1.8v 697.51n 1.8v 747.49n 1.8v 747.51n 1.8v 797.49n 1.8v 797.51n 1.8v 847.49n 1.8v 847.51n 1.8v 897.49n 1.8v 897.51n 1.8v 947.49n 1.8v 947.51n 1.8v 997.49n 1.8v 997.51n 1.8v 1047.49n 1.8v 1047.51n 1.8v 1097.49n 1.8v 1097.51n 1.8v 1147.49n 1.8v 1147.51n 1.8v 1197.49n 1.8v 1197.51n 1.8v 1247.49n 1.8v 1247.51n 1.8v 1297.49n 1.8v 1297.51n 1.8v 1347.49n 1.8v 1347.51n 1.8v 1397.49n 1.8v 1397.51n 1.8v 1447.49n 1.8v 1447.51n 1.8v 1497.49n 1.8v 1497.51n 0.0v 1547.49n 0.0v 1547.51n 0.0v 1597.49n 0.0v 1597.51n 1.8v 1647.49n 1.8v 1647.51n 1.8v 1697.49n 1.8v 1697.51n 1.8v 1747.49n 1.8v 1747.51n 1.8v 1797.49n 1.8v 1797.51n 0.0v 1847.49n 0.0v 1847.51n 0.0v 1897.49n 0.0v 1897.51n 0.0v 1947.49n 0.0v 1947.51n 0.0v 1997.49n 0.0v 1997.51n 0.0v 2047.49n 0.0v 2047.51n 0.0v 2097.49n 0.0v 2097.51n 0.0v 2147.49n 0.0v 2147.51n 0.0v 2197.49n 0.0v 2197.51n 0.0v 2247.49n 0.0v 2247.51n 1.8v 2297.49n 1.8v 2297.51n 1.8v 2347.49n 1.8v 2347.51n 1.8v 2397.49n 1.8v 2397.51n 1.8v 2447.49n 1.8v 2447.51n 1.8v 2497.49n 1.8v 2497.51n 1.8v 2547.49n 1.8v 2547.51n 1.8v 2597.49n 1.8v 2597.51n 1.8v 2647.49n 1.8v 2647.51n 1.8v 2697.49n 1.8v 2697.51n 1.8v 2747.49n 1.8v 2747.51n 1.8v 2797.49n 1.8v 2797.51n 0.0v 2847.49n 0.0v 2847.51n 0.0v 2897.49n 0.0v 2897.51n 0.0v 2947.49n 0.0v 2947.51n 0.0v 2997.49n 0.0v 2997.51n 0.0v 3047.49n 0.0v 3047.51n 0.0v 3097.49n 0.0v 3097.51n 1.8v 3147.49n 1.8v 3147.51n 1.8v 3197.49n 1.8v 3197.51n 1.8v 3247.49n 1.8v 3247.51n 1.8v 3297.49n 1.8v 3297.51n 1.8v 3347.49n 1.8v 3347.51n 1.8v 3397.49n 1.8v 3397.51n 1.8v 3447.49n 1.8v 3447.51n 1.8v 3497.49n 1.8v 3497.51n 1.8v 3547.49n 1.8v 3547.51n 1.8v 3597.49n 1.8v 3597.51n 1.8v 3647.49n 1.8v 3647.51n 1.8v 3697.49n 1.8v 3697.51n 1.8v 3747.49n 1.8v 3747.51n 1.8v 3797.49n 1.8v 3797.51n 1.8v 3847.49n 1.8v 3847.51n 1.8v 3897.49n 1.8v 3897.51n 1.8v 3947.49n 1.8v 3947.51n 1.8v 3997.49n 1.8v 3997.51n 1.8v 4047.49n 1.8v 4047.51n 1.8v 4097.49n 1.8v 4097.51n 0.0v 4147.49n 0.0v 4147.51n 0.0v 4197.49n 0.0v 4197.51n 0.0v 4247.49n 0.0v 4247.51n 0.0v 4297.49n 0.0v 4297.51n 0.0v 4347.49n 0.0v 4347.51n 0.0v 4397.49n 0.0v 4397.51n 0.0v 4447.49n 0.0v 4447.51n 0.0v 4497.49n 0.0v 4497.51n 0.0v 4547.49n 0.0v 4547.51n 0.0v 4597.49n 0.0v 4597.51n 0.0v 4647.49n 0.0v 4647.51n 0.0v 4697.49n 0.0v 4697.51n 0.0v 4747.49n 0.0v 4747.51n 1.8v 4797.49n 1.8v 4797.51n 0.0v 4847.49n 0.0v 4847.51n 0.0v 4897.49n 0.0v 4897.51n 0.0v 4947.49n 0.0v 4947.51n 0.0v 4997.49n 0.0v 4997.51n 0.0v 5047.49n 0.0v 5047.51n 0.0v 5097.49n 0.0v 5097.51n 0.0v 5147.49n 0.0v 5147.51n 0.0v 5197.49n 0.0v 5197.51n 0.0v 5247.49n 0.0v 5247.51n 0.0v 5297.49n 0.0v 5297.51n 0.0v 5347.49n 0.0v 5347.51n 0.0v 5397.49n 0.0v 5397.51n 0.0v 5447.49n 0.0v 5447.51n 0.0v 5497.49n 0.0v 5497.51n 1.8v 5547.49n 1.8v 5547.51n 1.8v 5597.49n 1.8v 5597.51n 1.8v 5647.49n 1.8v 5647.51n 1.8v 5697.49n 1.8v 5697.51n 1.8v 5747.49n 1.8v 5747.51n 1.8v 5797.49n 1.8v 5797.51n 1.8v 5847.49n 1.8v 5847.51n 1.8v 5897.49n 1.8v 5897.51n 1.8v 5947.49n 1.8v 5947.51n 1.8v 5997.49n 1.8v 5997.51n 0.0v 6047.49n 0.0v 6047.51n 0.0v 6097.49n 0.0v 6097.51n 1.8v 6147.49n 1.8v 6147.51n 1.8v 6197.49n 1.8v 6197.51n 1.8v 6247.49n 1.8v 6247.51n 1.8v 6297.49n 1.8v 6297.51n 1.8v 6347.49n 1.8v 6347.51n 1.8v 6397.49n 1.8v 6397.51n 1.8v 6447.49n 1.8v 6447.51n 1.8v 6497.49n 1.8v 6497.51n 1.8v 6547.49n 1.8v 6547.51n 1.8v 6597.49n 1.8v 6597.51n 0.0v 6647.49n 0.0v 6647.51n 0.0v 6697.49n 0.0v 6697.51n 0.0v 6747.49n 0.0v 6747.51n 0.0v 6797.49n 0.0v 6797.51n 0.0v 6847.49n 0.0v 6847.51n 0.0v 6897.49n 0.0v 6897.51n 0.0v 6947.49n 0.0v 6947.51n 0.0v 6997.49n 0.0v 6997.51n 0.0v 7047.49n 0.0v 7047.51n 0.0v 7097.49n 0.0v 7097.51n 0.0v 7147.49n 0.0v 7147.51n 0.0v 7197.49n 0.0v 7197.51n 0.0v 7247.49n 0.0v 7247.51n 0.0v 7297.49n 0.0v 7297.51n 0.0v 7347.49n 0.0v 7347.51n 0.0v 7397.49n 0.0v 7397.51n 0.0v 7447.49n 0.0v 7447.51n 1.8v 7497.49n 1.8v 7497.51n 1.8v 7547.49n 1.8v 7547.51n 1.8v 7597.49n 1.8v 7597.51n 1.8v 7647.49n 1.8v 7647.51n 1.8v 7697.49n 1.8v 7697.51n 1.8v 7747.49n 1.8v 7747.51n 1.8v 7797.49n 1.8v 7797.51n 1.8v 7847.49n 1.8v 7847.51n 0.0v 7897.49n 0.0v 7897.51n 0.0v 7947.49n 0.0v 7947.51n 0.0v 7997.49n 0.0v 7997.51n 0.0v 8047.49n 0.0v 8047.51n 0.0v 8097.49n 0.0v 8097.51n 0.0v 8147.49n 0.0v 8147.51n 0.0v 8197.49n 0.0v 8197.51n 0.0v 8247.49n 0.0v 8247.51n 0.0v 8297.49n 0.0v 8297.51n 0.0v 8347.49n 0.0v 8347.51n 0.0v 8397.49n 0.0v 8397.51n 0.0v 8447.49n 0.0v 8447.51n 1.8v 8497.49n 1.8v 8497.51n 1.8v 8547.49n 1.8v 8547.51n 1.8v 8597.49n 1.8v 8597.51n 1.8v 8647.49n 1.8v 8647.51n 1.8v 8697.49n 1.8v 8697.51n 1.8v 8747.49n 1.8v 8747.51n 0.0v 8797.49n 0.0v 8797.51n 0.0v 8847.49n 0.0v 8847.51n 0.0v 8897.49n 0.0v 8897.51n 0.0v 8947.49n 0.0v 8947.51n 0.0v 8997.49n 0.0v 8997.51n 1.8v 9047.49n 1.8v 9047.51n 0.0v 9097.49n 0.0v 9097.51n 0.0v 9147.49n 0.0v 9147.51n 0.0v 9197.49n 0.0v 9197.51n 0.0v 9247.49n 0.0v 9247.51n 0.0v 9297.49n 0.0v 9297.51n 0.0v 9347.49n 0.0v 9347.51n 0.0v 9397.49n 0.0v 9397.51n 0.0v 9447.49n 0.0v 9447.51n 0.0v 9497.49n 0.0v 9497.51n 0.0v 9547.49n 0.0v 9547.51n 0.0v 9597.49n 0.0v 9597.51n 1.8v 9647.49n 1.8v 9647.51n 1.8v 9697.49n 1.8v 9697.51n 1.8v 9747.49n 1.8v 9747.51n 1.8v 9797.49n 1.8v 9797.51n 1.8v 9847.49n 1.8v 9847.51n 1.8v 9897.49n 1.8v 9897.51n 1.8v 9947.49n 1.8v 9947.51n 1.8v 9997.49n 1.8v 9997.51n 1.8v 10047.49n 1.8v 10047.51n 1.8v 10097.49n 1.8v 10097.51n 1.8v 10147.49n 1.8v 10147.51n 1.8v 10197.49n 1.8v 10197.51n 1.8v 10247.49n 1.8v 10247.51n 1.8v )
* (time, data): [(0, 0), (50, 0), (100, 0), (150, 1), (200, 1), (250, 1), (300, 1), (350, 1), (400, 1), (450, 0), (500, 0), (550, 0), (600, 0), (650, 0), (700, 0), (750, 0), (800, 0), (850, 0), (900, 0), (950, 0), (1000, 0), (1050, 1), (1100, 1), (1150, 1), (1200, 1), (1250, 1), (1300, 1), (1350, 1), (1400, 0), (1450, 0), (1500, 0), (1550, 0), (1600, 1), (1650, 1), (1700, 1), (1750, 1), (1800, 0), (1850, 0), (1900, 0), (1950, 0), (2000, 0), (2050, 0), (2100, 0), (2150, 0), (2200, 0), (2250, 0), (2300, 0), (2350, 0), (2400, 0), (2450, 0), (2500, 0), (2550, 0), (2600, 0), (2650, 0), (2700, 0), (2750, 0), (2800, 1), (2850, 1), (2900, 1), (2950, 1), (3000, 1), (3050, 1), (3100, 1), (3150, 1), (3200, 1), (3250, 1), (3300, 1), (3350, 1), (3400, 1), (3450, 1), (3500, 1), (3550, 1), (3600, 1), (3650, 0), (3700, 0), (3750, 0), (3800, 0), (3850, 0), (3900, 0), (3950, 0), (4000, 0), (4050, 0), (4100, 0), (4150, 0), (4200, 0), (4250, 0), (4300, 0), (4350, 0), (4400, 0), (4450, 0), (4500, 0), (4550, 0), (4600, 0), (4650, 0), (4700, 0), (4750, 1), (4800, 1), (4850, 1), (4900, 1), (4950, 1), (5000, 1), (5050, 1), (5100, 1), (5150, 1), (5200, 1), (5250, 1), (5300, 1), (5350, 1), (5400, 1), (5450, 1), (5500, 1), (5550, 1), (5600, 1), (5650, 1), (5700, 1), (5750, 0), (5800, 0), (5850, 0), (5900, 0), (5950, 0), (6000, 0), (6050, 0), (6100, 0), (6150, 0), (6200, 0), (6250, 0), (6300, 0), (6350, 1), (6400, 1), (6450, 1), (6500, 1), (6550, 1), (6600, 1), (6650, 1), (6700, 1), (6750, 1), (6800, 1), (6850, 1), (6900, 1), (6950, 1), (7000, 1), (7050, 1), (7100, 1), (7150, 1), (7200, 0), (7250, 0), (7300, 0), (7350, 0), (7400, 0), (7450, 1), (7500, 0), (7550, 0), (7600, 0), (7650, 0), (7700, 1), (7750, 1), (7800, 0), (7850, 0), (7900, 0), (7950, 1), (8000, 1), (8050, 0), (8100, 0), (8150, 0), (8200, 0), (8250, 0), (8300, 0), (8350, 0), (8400, 0), (8450, 0), (8500, 0), (8550, 0), (8600, 0), (8650, 0), (8700, 0), (8750, 0), (8800, 0), (8850, 0), (8900, 1), (8950, 1), (9000, 0), (9050, 1), (9100, 1), (9150, 1), (9200, 1), (9250, 1), (9300, 1), (9350, 1), (9400, 0), (9450, 0), (9500, 0), (9550, 0), (9600, 1), (9650, 1), (9700, 1), (9750, 1), (9800, 1), (9850, 1), (9900, 1), (9950, 1), (10000, 1), (10050, 1), (10100, 1), (10150, 0), (10200, 0), (10250, 0)]
Vdin0_10  din0_10  0 PWL (0n 0.0v 47.49n 0.0v 47.51n 0.0v 97.49n 0.0v 97.51n 0.0v 147.49n 0.0v 147.51n 1.8v 197.49n 1.8v 197.51n 1.8v 247.49n 1.8v 247.51n 1.8v 297.49n 1.8v 297.51n 1.8v 347.49n 1.8v 347.51n 1.8v 397.49n 1.8v 397.51n 1.8v 447.49n 1.8v 447.51n 0.0v 497.49n 0.0v 497.51n 0.0v 547.49n 0.0v 547.51n 0.0v 597.49n 0.0v 597.51n 0.0v 647.49n 0.0v 647.51n 0.0v 697.49n 0.0v 697.51n 0.0v 747.49n 0.0v 747.51n 0.0v 797.49n 0.0v 797.51n 0.0v 847.49n 0.0v 847.51n 0.0v 897.49n 0.0v 897.51n 0.0v 947.49n 0.0v 947.51n 0.0v 997.49n 0.0v 997.51n 0.0v 1047.49n 0.0v 1047.51n 1.8v 1097.49n 1.8v 1097.51n 1.8v 1147.49n 1.8v 1147.51n 1.8v 1197.49n 1.8v 1197.51n 1.8v 1247.49n 1.8v 1247.51n 1.8v 1297.49n 1.8v 1297.51n 1.8v 1347.49n 1.8v 1347.51n 1.8v 1397.49n 1.8v 1397.51n 0.0v 1447.49n 0.0v 1447.51n 0.0v 1497.49n 0.0v 1497.51n 0.0v 1547.49n 0.0v 1547.51n 0.0v 1597.49n 0.0v 1597.51n 1.8v 1647.49n 1.8v 1647.51n 1.8v 1697.49n 1.8v 1697.51n 1.8v 1747.49n 1.8v 1747.51n 1.8v 1797.49n 1.8v 1797.51n 0.0v 1847.49n 0.0v 1847.51n 0.0v 1897.49n 0.0v 1897.51n 0.0v 1947.49n 0.0v 1947.51n 0.0v 1997.49n 0.0v 1997.51n 0.0v 2047.49n 0.0v 2047.51n 0.0v 2097.49n 0.0v 2097.51n 0.0v 2147.49n 0.0v 2147.51n 0.0v 2197.49n 0.0v 2197.51n 0.0v 2247.49n 0.0v 2247.51n 0.0v 2297.49n 0.0v 2297.51n 0.0v 2347.49n 0.0v 2347.51n 0.0v 2397.49n 0.0v 2397.51n 0.0v 2447.49n 0.0v 2447.51n 0.0v 2497.49n 0.0v 2497.51n 0.0v 2547.49n 0.0v 2547.51n 0.0v 2597.49n 0.0v 2597.51n 0.0v 2647.49n 0.0v 2647.51n 0.0v 2697.49n 0.0v 2697.51n 0.0v 2747.49n 0.0v 2747.51n 0.0v 2797.49n 0.0v 2797.51n 1.8v 2847.49n 1.8v 2847.51n 1.8v 2897.49n 1.8v 2897.51n 1.8v 2947.49n 1.8v 2947.51n 1.8v 2997.49n 1.8v 2997.51n 1.8v 3047.49n 1.8v 3047.51n 1.8v 3097.49n 1.8v 3097.51n 1.8v 3147.49n 1.8v 3147.51n 1.8v 3197.49n 1.8v 3197.51n 1.8v 3247.49n 1.8v 3247.51n 1.8v 3297.49n 1.8v 3297.51n 1.8v 3347.49n 1.8v 3347.51n 1.8v 3397.49n 1.8v 3397.51n 1.8v 3447.49n 1.8v 3447.51n 1.8v 3497.49n 1.8v 3497.51n 1.8v 3547.49n 1.8v 3547.51n 1.8v 3597.49n 1.8v 3597.51n 1.8v 3647.49n 1.8v 3647.51n 0.0v 3697.49n 0.0v 3697.51n 0.0v 3747.49n 0.0v 3747.51n 0.0v 3797.49n 0.0v 3797.51n 0.0v 3847.49n 0.0v 3847.51n 0.0v 3897.49n 0.0v 3897.51n 0.0v 3947.49n 0.0v 3947.51n 0.0v 3997.49n 0.0v 3997.51n 0.0v 4047.49n 0.0v 4047.51n 0.0v 4097.49n 0.0v 4097.51n 0.0v 4147.49n 0.0v 4147.51n 0.0v 4197.49n 0.0v 4197.51n 0.0v 4247.49n 0.0v 4247.51n 0.0v 4297.49n 0.0v 4297.51n 0.0v 4347.49n 0.0v 4347.51n 0.0v 4397.49n 0.0v 4397.51n 0.0v 4447.49n 0.0v 4447.51n 0.0v 4497.49n 0.0v 4497.51n 0.0v 4547.49n 0.0v 4547.51n 0.0v 4597.49n 0.0v 4597.51n 0.0v 4647.49n 0.0v 4647.51n 0.0v 4697.49n 0.0v 4697.51n 0.0v 4747.49n 0.0v 4747.51n 1.8v 4797.49n 1.8v 4797.51n 1.8v 4847.49n 1.8v 4847.51n 1.8v 4897.49n 1.8v 4897.51n 1.8v 4947.49n 1.8v 4947.51n 1.8v 4997.49n 1.8v 4997.51n 1.8v 5047.49n 1.8v 5047.51n 1.8v 5097.49n 1.8v 5097.51n 1.8v 5147.49n 1.8v 5147.51n 1.8v 5197.49n 1.8v 5197.51n 1.8v 5247.49n 1.8v 5247.51n 1.8v 5297.49n 1.8v 5297.51n 1.8v 5347.49n 1.8v 5347.51n 1.8v 5397.49n 1.8v 5397.51n 1.8v 5447.49n 1.8v 5447.51n 1.8v 5497.49n 1.8v 5497.51n 1.8v 5547.49n 1.8v 5547.51n 1.8v 5597.49n 1.8v 5597.51n 1.8v 5647.49n 1.8v 5647.51n 1.8v 5697.49n 1.8v 5697.51n 1.8v 5747.49n 1.8v 5747.51n 0.0v 5797.49n 0.0v 5797.51n 0.0v 5847.49n 0.0v 5847.51n 0.0v 5897.49n 0.0v 5897.51n 0.0v 5947.49n 0.0v 5947.51n 0.0v 5997.49n 0.0v 5997.51n 0.0v 6047.49n 0.0v 6047.51n 0.0v 6097.49n 0.0v 6097.51n 0.0v 6147.49n 0.0v 6147.51n 0.0v 6197.49n 0.0v 6197.51n 0.0v 6247.49n 0.0v 6247.51n 0.0v 6297.49n 0.0v 6297.51n 0.0v 6347.49n 0.0v 6347.51n 1.8v 6397.49n 1.8v 6397.51n 1.8v 6447.49n 1.8v 6447.51n 1.8v 6497.49n 1.8v 6497.51n 1.8v 6547.49n 1.8v 6547.51n 1.8v 6597.49n 1.8v 6597.51n 1.8v 6647.49n 1.8v 6647.51n 1.8v 6697.49n 1.8v 6697.51n 1.8v 6747.49n 1.8v 6747.51n 1.8v 6797.49n 1.8v 6797.51n 1.8v 6847.49n 1.8v 6847.51n 1.8v 6897.49n 1.8v 6897.51n 1.8v 6947.49n 1.8v 6947.51n 1.8v 6997.49n 1.8v 6997.51n 1.8v 7047.49n 1.8v 7047.51n 1.8v 7097.49n 1.8v 7097.51n 1.8v 7147.49n 1.8v 7147.51n 1.8v 7197.49n 1.8v 7197.51n 0.0v 7247.49n 0.0v 7247.51n 0.0v 7297.49n 0.0v 7297.51n 0.0v 7347.49n 0.0v 7347.51n 0.0v 7397.49n 0.0v 7397.51n 0.0v 7447.49n 0.0v 7447.51n 1.8v 7497.49n 1.8v 7497.51n 0.0v 7547.49n 0.0v 7547.51n 0.0v 7597.49n 0.0v 7597.51n 0.0v 7647.49n 0.0v 7647.51n 0.0v 7697.49n 0.0v 7697.51n 1.8v 7747.49n 1.8v 7747.51n 1.8v 7797.49n 1.8v 7797.51n 0.0v 7847.49n 0.0v 7847.51n 0.0v 7897.49n 0.0v 7897.51n 0.0v 7947.49n 0.0v 7947.51n 1.8v 7997.49n 1.8v 7997.51n 1.8v 8047.49n 1.8v 8047.51n 0.0v 8097.49n 0.0v 8097.51n 0.0v 8147.49n 0.0v 8147.51n 0.0v 8197.49n 0.0v 8197.51n 0.0v 8247.49n 0.0v 8247.51n 0.0v 8297.49n 0.0v 8297.51n 0.0v 8347.49n 0.0v 8347.51n 0.0v 8397.49n 0.0v 8397.51n 0.0v 8447.49n 0.0v 8447.51n 0.0v 8497.49n 0.0v 8497.51n 0.0v 8547.49n 0.0v 8547.51n 0.0v 8597.49n 0.0v 8597.51n 0.0v 8647.49n 0.0v 8647.51n 0.0v 8697.49n 0.0v 8697.51n 0.0v 8747.49n 0.0v 8747.51n 0.0v 8797.49n 0.0v 8797.51n 0.0v 8847.49n 0.0v 8847.51n 0.0v 8897.49n 0.0v 8897.51n 1.8v 8947.49n 1.8v 8947.51n 1.8v 8997.49n 1.8v 8997.51n 0.0v 9047.49n 0.0v 9047.51n 1.8v 9097.49n 1.8v 9097.51n 1.8v 9147.49n 1.8v 9147.51n 1.8v 9197.49n 1.8v 9197.51n 1.8v 9247.49n 1.8v 9247.51n 1.8v 9297.49n 1.8v 9297.51n 1.8v 9347.49n 1.8v 9347.51n 1.8v 9397.49n 1.8v 9397.51n 0.0v 9447.49n 0.0v 9447.51n 0.0v 9497.49n 0.0v 9497.51n 0.0v 9547.49n 0.0v 9547.51n 0.0v 9597.49n 0.0v 9597.51n 1.8v 9647.49n 1.8v 9647.51n 1.8v 9697.49n 1.8v 9697.51n 1.8v 9747.49n 1.8v 9747.51n 1.8v 9797.49n 1.8v 9797.51n 1.8v 9847.49n 1.8v 9847.51n 1.8v 9897.49n 1.8v 9897.51n 1.8v 9947.49n 1.8v 9947.51n 1.8v 9997.49n 1.8v 9997.51n 1.8v 10047.49n 1.8v 10047.51n 1.8v 10097.49n 1.8v 10097.51n 1.8v 10147.49n 1.8v 10147.51n 0.0v 10197.49n 0.0v 10197.51n 0.0v 10247.49n 0.0v 10247.51n 0.0v )
* (time, data): [(0, 0), (50, 0), (100, 0), (150, 0), (200, 0), (250, 0), (300, 0), (350, 1), (400, 1), (450, 1), (500, 1), (550, 1), (600, 1), (650, 0), (700, 0), (750, 0), (800, 0), (850, 0), (900, 0), (950, 0), (1000, 0), (1050, 1), (1100, 1), (1150, 0), (1200, 0), (1250, 0), (1300, 0), (1350, 0), (1400, 1), (1450, 1), (1500, 0), (1550, 0), (1600, 1), (1650, 1), (1700, 1), (1750, 1), (1800, 0), (1850, 0), (1900, 0), (1950, 1), (2000, 1), (2050, 1), (2100, 1), (2150, 1), (2200, 1), (2250, 0), (2300, 0), (2350, 0), (2400, 0), (2450, 0), (2500, 0), (2550, 0), (2600, 0), (2650, 0), (2700, 0), (2750, 0), (2800, 1), (2850, 0), (2900, 0), (2950, 0), (3000, 0), (3050, 0), (3100, 1), (3150, 1), (3200, 0), (3250, 0), (3300, 0), (3350, 0), (3400, 0), (3450, 0), (3500, 0), (3550, 0), (3600, 0), (3650, 0), (3700, 0), (3750, 0), (3800, 0), (3850, 0), (3900, 0), (3950, 0), (4000, 0), (4050, 0), (4100, 0), (4150, 0), (4200, 0), (4250, 0), (4300, 0), (4350, 0), (4400, 0), (4450, 0), (4500, 1), (4550, 1), (4600, 1), (4650, 1), (4700, 1), (4750, 1), (4800, 0), (4850, 0), (4900, 1), (4950, 1), (5000, 1), (5050, 1), (5100, 1), (5150, 1), (5200, 1), (5250, 1), (5300, 0), (5350, 0), (5400, 0), (5450, 0), (5500, 1), (5550, 1), (5600, 0), (5650, 0), (5700, 0), (5750, 1), (5800, 1), (5850, 1), (5900, 1), (5950, 1), (6000, 0), (6050, 0), (6100, 1), (6150, 1), (6200, 1), (6250, 1), (6300, 1), (6350, 0), (6400, 0), (6450, 0), (6500, 0), (6550, 0), (6600, 1), (6650, 1), (6700, 1), (6750, 1), (6800, 1), (6850, 1), (6900, 1), (6950, 1), (7000, 1), (7050, 1), (7100, 1), (7150, 1), (7200, 0), (7250, 0), (7300, 0), (7350, 0), (7400, 0), (7450, 1), (7500, 0), (7550, 0), (7600, 0), (7650, 0), (7700, 0), (7750, 0), (7800, 0), (7850, 1), (7900, 1), (7950, 0), (8000, 0), (8050, 0), (8100, 0), (8150, 1), (8200, 1), (8250, 1), (8300, 1), (8350, 1), (8400, 1), (8450, 1), (8500, 1), (8550, 1), (8600, 1), (8650, 1), (8700, 1), (8750, 0), (8800, 0), (8850, 0), (8900, 1), (8950, 1), (9000, 0), (9050, 0), (9100, 0), (9150, 0), (9200, 0), (9250, 0), (9300, 0), (9350, 0), (9400, 1), (9450, 1), (9500, 1), (9550, 1), (9600, 1), (9650, 1), (9700, 1), (9750, 1), (9800, 1), (9850, 1), (9900, 1), (9950, 1), (10000, 1), (10050, 1), (10100, 1), (10150, 0), (10200, 0), (10250, 0)]
Vdin0_11  din0_11  0 PWL (0n 0.0v 47.49n 0.0v 47.51n 0.0v 97.49n 0.0v 97.51n 0.0v 147.49n 0.0v 147.51n 0.0v 197.49n 0.0v 197.51n 0.0v 247.49n 0.0v 247.51n 0.0v 297.49n 0.0v 297.51n 0.0v 347.49n 0.0v 347.51n 1.8v 397.49n 1.8v 397.51n 1.8v 447.49n 1.8v 447.51n 1.8v 497.49n 1.8v 497.51n 1.8v 547.49n 1.8v 547.51n 1.8v 597.49n 1.8v 597.51n 1.8v 647.49n 1.8v 647.51n 0.0v 697.49n 0.0v 697.51n 0.0v 747.49n 0.0v 747.51n 0.0v 797.49n 0.0v 797.51n 0.0v 847.49n 0.0v 847.51n 0.0v 897.49n 0.0v 897.51n 0.0v 947.49n 0.0v 947.51n 0.0v 997.49n 0.0v 997.51n 0.0v 1047.49n 0.0v 1047.51n 1.8v 1097.49n 1.8v 1097.51n 1.8v 1147.49n 1.8v 1147.51n 0.0v 1197.49n 0.0v 1197.51n 0.0v 1247.49n 0.0v 1247.51n 0.0v 1297.49n 0.0v 1297.51n 0.0v 1347.49n 0.0v 1347.51n 0.0v 1397.49n 0.0v 1397.51n 1.8v 1447.49n 1.8v 1447.51n 1.8v 1497.49n 1.8v 1497.51n 0.0v 1547.49n 0.0v 1547.51n 0.0v 1597.49n 0.0v 1597.51n 1.8v 1647.49n 1.8v 1647.51n 1.8v 1697.49n 1.8v 1697.51n 1.8v 1747.49n 1.8v 1747.51n 1.8v 1797.49n 1.8v 1797.51n 0.0v 1847.49n 0.0v 1847.51n 0.0v 1897.49n 0.0v 1897.51n 0.0v 1947.49n 0.0v 1947.51n 1.8v 1997.49n 1.8v 1997.51n 1.8v 2047.49n 1.8v 2047.51n 1.8v 2097.49n 1.8v 2097.51n 1.8v 2147.49n 1.8v 2147.51n 1.8v 2197.49n 1.8v 2197.51n 1.8v 2247.49n 1.8v 2247.51n 0.0v 2297.49n 0.0v 2297.51n 0.0v 2347.49n 0.0v 2347.51n 0.0v 2397.49n 0.0v 2397.51n 0.0v 2447.49n 0.0v 2447.51n 0.0v 2497.49n 0.0v 2497.51n 0.0v 2547.49n 0.0v 2547.51n 0.0v 2597.49n 0.0v 2597.51n 0.0v 2647.49n 0.0v 2647.51n 0.0v 2697.49n 0.0v 2697.51n 0.0v 2747.49n 0.0v 2747.51n 0.0v 2797.49n 0.0v 2797.51n 1.8v 2847.49n 1.8v 2847.51n 0.0v 2897.49n 0.0v 2897.51n 0.0v 2947.49n 0.0v 2947.51n 0.0v 2997.49n 0.0v 2997.51n 0.0v 3047.49n 0.0v 3047.51n 0.0v 3097.49n 0.0v 3097.51n 1.8v 3147.49n 1.8v 3147.51n 1.8v 3197.49n 1.8v 3197.51n 0.0v 3247.49n 0.0v 3247.51n 0.0v 3297.49n 0.0v 3297.51n 0.0v 3347.49n 0.0v 3347.51n 0.0v 3397.49n 0.0v 3397.51n 0.0v 3447.49n 0.0v 3447.51n 0.0v 3497.49n 0.0v 3497.51n 0.0v 3547.49n 0.0v 3547.51n 0.0v 3597.49n 0.0v 3597.51n 0.0v 3647.49n 0.0v 3647.51n 0.0v 3697.49n 0.0v 3697.51n 0.0v 3747.49n 0.0v 3747.51n 0.0v 3797.49n 0.0v 3797.51n 0.0v 3847.49n 0.0v 3847.51n 0.0v 3897.49n 0.0v 3897.51n 0.0v 3947.49n 0.0v 3947.51n 0.0v 3997.49n 0.0v 3997.51n 0.0v 4047.49n 0.0v 4047.51n 0.0v 4097.49n 0.0v 4097.51n 0.0v 4147.49n 0.0v 4147.51n 0.0v 4197.49n 0.0v 4197.51n 0.0v 4247.49n 0.0v 4247.51n 0.0v 4297.49n 0.0v 4297.51n 0.0v 4347.49n 0.0v 4347.51n 0.0v 4397.49n 0.0v 4397.51n 0.0v 4447.49n 0.0v 4447.51n 0.0v 4497.49n 0.0v 4497.51n 1.8v 4547.49n 1.8v 4547.51n 1.8v 4597.49n 1.8v 4597.51n 1.8v 4647.49n 1.8v 4647.51n 1.8v 4697.49n 1.8v 4697.51n 1.8v 4747.49n 1.8v 4747.51n 1.8v 4797.49n 1.8v 4797.51n 0.0v 4847.49n 0.0v 4847.51n 0.0v 4897.49n 0.0v 4897.51n 1.8v 4947.49n 1.8v 4947.51n 1.8v 4997.49n 1.8v 4997.51n 1.8v 5047.49n 1.8v 5047.51n 1.8v 5097.49n 1.8v 5097.51n 1.8v 5147.49n 1.8v 5147.51n 1.8v 5197.49n 1.8v 5197.51n 1.8v 5247.49n 1.8v 5247.51n 1.8v 5297.49n 1.8v 5297.51n 0.0v 5347.49n 0.0v 5347.51n 0.0v 5397.49n 0.0v 5397.51n 0.0v 5447.49n 0.0v 5447.51n 0.0v 5497.49n 0.0v 5497.51n 1.8v 5547.49n 1.8v 5547.51n 1.8v 5597.49n 1.8v 5597.51n 0.0v 5647.49n 0.0v 5647.51n 0.0v 5697.49n 0.0v 5697.51n 0.0v 5747.49n 0.0v 5747.51n 1.8v 5797.49n 1.8v 5797.51n 1.8v 5847.49n 1.8v 5847.51n 1.8v 5897.49n 1.8v 5897.51n 1.8v 5947.49n 1.8v 5947.51n 1.8v 5997.49n 1.8v 5997.51n 0.0v 6047.49n 0.0v 6047.51n 0.0v 6097.49n 0.0v 6097.51n 1.8v 6147.49n 1.8v 6147.51n 1.8v 6197.49n 1.8v 6197.51n 1.8v 6247.49n 1.8v 6247.51n 1.8v 6297.49n 1.8v 6297.51n 1.8v 6347.49n 1.8v 6347.51n 0.0v 6397.49n 0.0v 6397.51n 0.0v 6447.49n 0.0v 6447.51n 0.0v 6497.49n 0.0v 6497.51n 0.0v 6547.49n 0.0v 6547.51n 0.0v 6597.49n 0.0v 6597.51n 1.8v 6647.49n 1.8v 6647.51n 1.8v 6697.49n 1.8v 6697.51n 1.8v 6747.49n 1.8v 6747.51n 1.8v 6797.49n 1.8v 6797.51n 1.8v 6847.49n 1.8v 6847.51n 1.8v 6897.49n 1.8v 6897.51n 1.8v 6947.49n 1.8v 6947.51n 1.8v 6997.49n 1.8v 6997.51n 1.8v 7047.49n 1.8v 7047.51n 1.8v 7097.49n 1.8v 7097.51n 1.8v 7147.49n 1.8v 7147.51n 1.8v 7197.49n 1.8v 7197.51n 0.0v 7247.49n 0.0v 7247.51n 0.0v 7297.49n 0.0v 7297.51n 0.0v 7347.49n 0.0v 7347.51n 0.0v 7397.49n 0.0v 7397.51n 0.0v 7447.49n 0.0v 7447.51n 1.8v 7497.49n 1.8v 7497.51n 0.0v 7547.49n 0.0v 7547.51n 0.0v 7597.49n 0.0v 7597.51n 0.0v 7647.49n 0.0v 7647.51n 0.0v 7697.49n 0.0v 7697.51n 0.0v 7747.49n 0.0v 7747.51n 0.0v 7797.49n 0.0v 7797.51n 0.0v 7847.49n 0.0v 7847.51n 1.8v 7897.49n 1.8v 7897.51n 1.8v 7947.49n 1.8v 7947.51n 0.0v 7997.49n 0.0v 7997.51n 0.0v 8047.49n 0.0v 8047.51n 0.0v 8097.49n 0.0v 8097.51n 0.0v 8147.49n 0.0v 8147.51n 1.8v 8197.49n 1.8v 8197.51n 1.8v 8247.49n 1.8v 8247.51n 1.8v 8297.49n 1.8v 8297.51n 1.8v 8347.49n 1.8v 8347.51n 1.8v 8397.49n 1.8v 8397.51n 1.8v 8447.49n 1.8v 8447.51n 1.8v 8497.49n 1.8v 8497.51n 1.8v 8547.49n 1.8v 8547.51n 1.8v 8597.49n 1.8v 8597.51n 1.8v 8647.49n 1.8v 8647.51n 1.8v 8697.49n 1.8v 8697.51n 1.8v 8747.49n 1.8v 8747.51n 0.0v 8797.49n 0.0v 8797.51n 0.0v 8847.49n 0.0v 8847.51n 0.0v 8897.49n 0.0v 8897.51n 1.8v 8947.49n 1.8v 8947.51n 1.8v 8997.49n 1.8v 8997.51n 0.0v 9047.49n 0.0v 9047.51n 0.0v 9097.49n 0.0v 9097.51n 0.0v 9147.49n 0.0v 9147.51n 0.0v 9197.49n 0.0v 9197.51n 0.0v 9247.49n 0.0v 9247.51n 0.0v 9297.49n 0.0v 9297.51n 0.0v 9347.49n 0.0v 9347.51n 0.0v 9397.49n 0.0v 9397.51n 1.8v 9447.49n 1.8v 9447.51n 1.8v 9497.49n 1.8v 9497.51n 1.8v 9547.49n 1.8v 9547.51n 1.8v 9597.49n 1.8v 9597.51n 1.8v 9647.49n 1.8v 9647.51n 1.8v 9697.49n 1.8v 9697.51n 1.8v 9747.49n 1.8v 9747.51n 1.8v 9797.49n 1.8v 9797.51n 1.8v 9847.49n 1.8v 9847.51n 1.8v 9897.49n 1.8v 9897.51n 1.8v 9947.49n 1.8v 9947.51n 1.8v 9997.49n 1.8v 9997.51n 1.8v 10047.49n 1.8v 10047.51n 1.8v 10097.49n 1.8v 10097.51n 1.8v 10147.49n 1.8v 10147.51n 0.0v 10197.49n 0.0v 10197.51n 0.0v 10247.49n 0.0v 10247.51n 0.0v )
* (time, data): [(0, 0), (50, 1), (100, 1), (150, 0), (200, 0), (250, 0), (300, 0), (350, 0), (400, 0), (450, 1), (500, 1), (550, 1), (600, 1), (650, 1), (700, 1), (750, 1), (800, 1), (850, 1), (900, 1), (950, 1), (1000, 1), (1050, 0), (1100, 0), (1150, 0), (1200, 0), (1250, 0), (1300, 0), (1350, 0), (1400, 1), (1450, 1), (1500, 1), (1550, 1), (1600, 1), (1650, 1), (1700, 1), (1750, 1), (1800, 1), (1850, 1), (1900, 1), (1950, 0), (2000, 0), (2050, 0), (2100, 0), (2150, 0), (2200, 0), (2250, 1), (2300, 1), (2350, 1), (2400, 1), (2450, 1), (2500, 1), (2550, 1), (2600, 1), (2650, 1), (2700, 1), (2750, 1), (2800, 0), (2850, 0), (2900, 0), (2950, 0), (3000, 0), (3050, 0), (3100, 1), (3150, 1), (3200, 0), (3250, 0), (3300, 0), (3350, 0), (3400, 0), (3450, 0), (3500, 0), (3550, 0), (3600, 0), (3650, 0), (3700, 0), (3750, 0), (3800, 0), (3850, 0), (3900, 0), (3950, 0), (4000, 0), (4050, 0), (4100, 1), (4150, 1), (4200, 1), (4250, 1), (4300, 1), (4350, 1), (4400, 1), (4450, 1), (4500, 1), (4550, 1), (4600, 1), (4650, 1), (4700, 1), (4750, 0), (4800, 0), (4850, 0), (4900, 1), (4950, 1), (5000, 1), (5050, 1), (5100, 1), (5150, 1), (5200, 1), (5250, 1), (5300, 0), (5350, 0), (5400, 0), (5450, 0), (5500, 0), (5550, 0), (5600, 1), (5650, 1), (5700, 1), (5750, 1), (5800, 1), (5850, 1), (5900, 1), (5950, 0), (6000, 1), (6050, 1), (6100, 1), (6150, 1), (6200, 1), (6250, 1), (6300, 1), (6350, 1), (6400, 1), (6450, 1), (6500, 1), (6550, 1), (6600, 0), (6650, 0), (6700, 0), (6750, 0), (6800, 0), (6850, 0), (6900, 0), (6950, 0), (7000, 0), (7050, 0), (7100, 0), (7150, 0), (7200, 0), (7250, 0), (7300, 0), (7350, 0), (7400, 0), (7450, 0), (7500, 0), (7550, 0), (7600, 0), (7650, 0), (7700, 0), (7750, 0), (7800, 1), (7850, 1), (7900, 1), (7950, 0), (8000, 0), (8050, 1), (8100, 1), (8150, 1), (8200, 1), (8250, 1), (8300, 1), (8350, 1), (8400, 1), (8450, 0), (8500, 0), (8550, 0), (8600, 0), (8650, 0), (8700, 0), (8750, 0), (8800, 0), (8850, 0), (8900, 1), (8950, 1), (9000, 0), (9050, 0), (9100, 0), (9150, 0), (9200, 0), (9250, 0), (9300, 0), (9350, 0), (9400, 0), (9450, 0), (9500, 0), (9550, 0), (9600, 1), (9650, 1), (9700, 1), (9750, 1), (9800, 1), (9850, 1), (9900, 1), (9950, 1), (10000, 0), (10050, 0), (10100, 0), (10150, 1), (10200, 1), (10250, 1)]
Vdin0_12  din0_12  0 PWL (0n 0.0v 47.49n 0.0v 47.51n 1.8v 97.49n 1.8v 97.51n 1.8v 147.49n 1.8v 147.51n 0.0v 197.49n 0.0v 197.51n 0.0v 247.49n 0.0v 247.51n 0.0v 297.49n 0.0v 297.51n 0.0v 347.49n 0.0v 347.51n 0.0v 397.49n 0.0v 397.51n 0.0v 447.49n 0.0v 447.51n 1.8v 497.49n 1.8v 497.51n 1.8v 547.49n 1.8v 547.51n 1.8v 597.49n 1.8v 597.51n 1.8v 647.49n 1.8v 647.51n 1.8v 697.49n 1.8v 697.51n 1.8v 747.49n 1.8v 747.51n 1.8v 797.49n 1.8v 797.51n 1.8v 847.49n 1.8v 847.51n 1.8v 897.49n 1.8v 897.51n 1.8v 947.49n 1.8v 947.51n 1.8v 997.49n 1.8v 997.51n 1.8v 1047.49n 1.8v 1047.51n 0.0v 1097.49n 0.0v 1097.51n 0.0v 1147.49n 0.0v 1147.51n 0.0v 1197.49n 0.0v 1197.51n 0.0v 1247.49n 0.0v 1247.51n 0.0v 1297.49n 0.0v 1297.51n 0.0v 1347.49n 0.0v 1347.51n 0.0v 1397.49n 0.0v 1397.51n 1.8v 1447.49n 1.8v 1447.51n 1.8v 1497.49n 1.8v 1497.51n 1.8v 1547.49n 1.8v 1547.51n 1.8v 1597.49n 1.8v 1597.51n 1.8v 1647.49n 1.8v 1647.51n 1.8v 1697.49n 1.8v 1697.51n 1.8v 1747.49n 1.8v 1747.51n 1.8v 1797.49n 1.8v 1797.51n 1.8v 1847.49n 1.8v 1847.51n 1.8v 1897.49n 1.8v 1897.51n 1.8v 1947.49n 1.8v 1947.51n 0.0v 1997.49n 0.0v 1997.51n 0.0v 2047.49n 0.0v 2047.51n 0.0v 2097.49n 0.0v 2097.51n 0.0v 2147.49n 0.0v 2147.51n 0.0v 2197.49n 0.0v 2197.51n 0.0v 2247.49n 0.0v 2247.51n 1.8v 2297.49n 1.8v 2297.51n 1.8v 2347.49n 1.8v 2347.51n 1.8v 2397.49n 1.8v 2397.51n 1.8v 2447.49n 1.8v 2447.51n 1.8v 2497.49n 1.8v 2497.51n 1.8v 2547.49n 1.8v 2547.51n 1.8v 2597.49n 1.8v 2597.51n 1.8v 2647.49n 1.8v 2647.51n 1.8v 2697.49n 1.8v 2697.51n 1.8v 2747.49n 1.8v 2747.51n 1.8v 2797.49n 1.8v 2797.51n 0.0v 2847.49n 0.0v 2847.51n 0.0v 2897.49n 0.0v 2897.51n 0.0v 2947.49n 0.0v 2947.51n 0.0v 2997.49n 0.0v 2997.51n 0.0v 3047.49n 0.0v 3047.51n 0.0v 3097.49n 0.0v 3097.51n 1.8v 3147.49n 1.8v 3147.51n 1.8v 3197.49n 1.8v 3197.51n 0.0v 3247.49n 0.0v 3247.51n 0.0v 3297.49n 0.0v 3297.51n 0.0v 3347.49n 0.0v 3347.51n 0.0v 3397.49n 0.0v 3397.51n 0.0v 3447.49n 0.0v 3447.51n 0.0v 3497.49n 0.0v 3497.51n 0.0v 3547.49n 0.0v 3547.51n 0.0v 3597.49n 0.0v 3597.51n 0.0v 3647.49n 0.0v 3647.51n 0.0v 3697.49n 0.0v 3697.51n 0.0v 3747.49n 0.0v 3747.51n 0.0v 3797.49n 0.0v 3797.51n 0.0v 3847.49n 0.0v 3847.51n 0.0v 3897.49n 0.0v 3897.51n 0.0v 3947.49n 0.0v 3947.51n 0.0v 3997.49n 0.0v 3997.51n 0.0v 4047.49n 0.0v 4047.51n 0.0v 4097.49n 0.0v 4097.51n 1.8v 4147.49n 1.8v 4147.51n 1.8v 4197.49n 1.8v 4197.51n 1.8v 4247.49n 1.8v 4247.51n 1.8v 4297.49n 1.8v 4297.51n 1.8v 4347.49n 1.8v 4347.51n 1.8v 4397.49n 1.8v 4397.51n 1.8v 4447.49n 1.8v 4447.51n 1.8v 4497.49n 1.8v 4497.51n 1.8v 4547.49n 1.8v 4547.51n 1.8v 4597.49n 1.8v 4597.51n 1.8v 4647.49n 1.8v 4647.51n 1.8v 4697.49n 1.8v 4697.51n 1.8v 4747.49n 1.8v 4747.51n 0.0v 4797.49n 0.0v 4797.51n 0.0v 4847.49n 0.0v 4847.51n 0.0v 4897.49n 0.0v 4897.51n 1.8v 4947.49n 1.8v 4947.51n 1.8v 4997.49n 1.8v 4997.51n 1.8v 5047.49n 1.8v 5047.51n 1.8v 5097.49n 1.8v 5097.51n 1.8v 5147.49n 1.8v 5147.51n 1.8v 5197.49n 1.8v 5197.51n 1.8v 5247.49n 1.8v 5247.51n 1.8v 5297.49n 1.8v 5297.51n 0.0v 5347.49n 0.0v 5347.51n 0.0v 5397.49n 0.0v 5397.51n 0.0v 5447.49n 0.0v 5447.51n 0.0v 5497.49n 0.0v 5497.51n 0.0v 5547.49n 0.0v 5547.51n 0.0v 5597.49n 0.0v 5597.51n 1.8v 5647.49n 1.8v 5647.51n 1.8v 5697.49n 1.8v 5697.51n 1.8v 5747.49n 1.8v 5747.51n 1.8v 5797.49n 1.8v 5797.51n 1.8v 5847.49n 1.8v 5847.51n 1.8v 5897.49n 1.8v 5897.51n 1.8v 5947.49n 1.8v 5947.51n 0.0v 5997.49n 0.0v 5997.51n 1.8v 6047.49n 1.8v 6047.51n 1.8v 6097.49n 1.8v 6097.51n 1.8v 6147.49n 1.8v 6147.51n 1.8v 6197.49n 1.8v 6197.51n 1.8v 6247.49n 1.8v 6247.51n 1.8v 6297.49n 1.8v 6297.51n 1.8v 6347.49n 1.8v 6347.51n 1.8v 6397.49n 1.8v 6397.51n 1.8v 6447.49n 1.8v 6447.51n 1.8v 6497.49n 1.8v 6497.51n 1.8v 6547.49n 1.8v 6547.51n 1.8v 6597.49n 1.8v 6597.51n 0.0v 6647.49n 0.0v 6647.51n 0.0v 6697.49n 0.0v 6697.51n 0.0v 6747.49n 0.0v 6747.51n 0.0v 6797.49n 0.0v 6797.51n 0.0v 6847.49n 0.0v 6847.51n 0.0v 6897.49n 0.0v 6897.51n 0.0v 6947.49n 0.0v 6947.51n 0.0v 6997.49n 0.0v 6997.51n 0.0v 7047.49n 0.0v 7047.51n 0.0v 7097.49n 0.0v 7097.51n 0.0v 7147.49n 0.0v 7147.51n 0.0v 7197.49n 0.0v 7197.51n 0.0v 7247.49n 0.0v 7247.51n 0.0v 7297.49n 0.0v 7297.51n 0.0v 7347.49n 0.0v 7347.51n 0.0v 7397.49n 0.0v 7397.51n 0.0v 7447.49n 0.0v 7447.51n 0.0v 7497.49n 0.0v 7497.51n 0.0v 7547.49n 0.0v 7547.51n 0.0v 7597.49n 0.0v 7597.51n 0.0v 7647.49n 0.0v 7647.51n 0.0v 7697.49n 0.0v 7697.51n 0.0v 7747.49n 0.0v 7747.51n 0.0v 7797.49n 0.0v 7797.51n 1.8v 7847.49n 1.8v 7847.51n 1.8v 7897.49n 1.8v 7897.51n 1.8v 7947.49n 1.8v 7947.51n 0.0v 7997.49n 0.0v 7997.51n 0.0v 8047.49n 0.0v 8047.51n 1.8v 8097.49n 1.8v 8097.51n 1.8v 8147.49n 1.8v 8147.51n 1.8v 8197.49n 1.8v 8197.51n 1.8v 8247.49n 1.8v 8247.51n 1.8v 8297.49n 1.8v 8297.51n 1.8v 8347.49n 1.8v 8347.51n 1.8v 8397.49n 1.8v 8397.51n 1.8v 8447.49n 1.8v 8447.51n 0.0v 8497.49n 0.0v 8497.51n 0.0v 8547.49n 0.0v 8547.51n 0.0v 8597.49n 0.0v 8597.51n 0.0v 8647.49n 0.0v 8647.51n 0.0v 8697.49n 0.0v 8697.51n 0.0v 8747.49n 0.0v 8747.51n 0.0v 8797.49n 0.0v 8797.51n 0.0v 8847.49n 0.0v 8847.51n 0.0v 8897.49n 0.0v 8897.51n 1.8v 8947.49n 1.8v 8947.51n 1.8v 8997.49n 1.8v 8997.51n 0.0v 9047.49n 0.0v 9047.51n 0.0v 9097.49n 0.0v 9097.51n 0.0v 9147.49n 0.0v 9147.51n 0.0v 9197.49n 0.0v 9197.51n 0.0v 9247.49n 0.0v 9247.51n 0.0v 9297.49n 0.0v 9297.51n 0.0v 9347.49n 0.0v 9347.51n 0.0v 9397.49n 0.0v 9397.51n 0.0v 9447.49n 0.0v 9447.51n 0.0v 9497.49n 0.0v 9497.51n 0.0v 9547.49n 0.0v 9547.51n 0.0v 9597.49n 0.0v 9597.51n 1.8v 9647.49n 1.8v 9647.51n 1.8v 9697.49n 1.8v 9697.51n 1.8v 9747.49n 1.8v 9747.51n 1.8v 9797.49n 1.8v 9797.51n 1.8v 9847.49n 1.8v 9847.51n 1.8v 9897.49n 1.8v 9897.51n 1.8v 9947.49n 1.8v 9947.51n 1.8v 9997.49n 1.8v 9997.51n 0.0v 10047.49n 0.0v 10047.51n 0.0v 10097.49n 0.0v 10097.51n 0.0v 10147.49n 0.0v 10147.51n 1.8v 10197.49n 1.8v 10197.51n 1.8v 10247.49n 1.8v 10247.51n 1.8v )
* (time, data): [(0, 0), (50, 0), (100, 0), (150, 0), (200, 0), (250, 0), (300, 0), (350, 1), (400, 1), (450, 1), (500, 1), (550, 1), (600, 1), (650, 0), (700, 0), (750, 0), (800, 0), (850, 0), (900, 0), (950, 0), (1000, 0), (1050, 1), (1100, 1), (1150, 1), (1200, 1), (1250, 1), (1300, 1), (1350, 1), (1400, 1), (1450, 1), (1500, 0), (1550, 0), (1600, 1), (1650, 1), (1700, 1), (1750, 1), (1800, 1), (1850, 1), (1900, 1), (1950, 0), (2000, 0), (2050, 0), (2100, 0), (2150, 0), (2200, 0), (2250, 0), (2300, 0), (2350, 0), (2400, 0), (2450, 0), (2500, 0), (2550, 0), (2600, 0), (2650, 0), (2700, 0), (2750, 0), (2800, 0), (2850, 1), (2900, 1), (2950, 1), (3000, 1), (3050, 1), (3100, 1), (3150, 1), (3200, 1), (3250, 1), (3300, 1), (3350, 1), (3400, 1), (3450, 0), (3500, 0), (3550, 0), (3600, 0), (3650, 1), (3700, 1), (3750, 1), (3800, 1), (3850, 1), (3900, 1), (3950, 1), (4000, 1), (4050, 1), (4100, 1), (4150, 1), (4200, 1), (4250, 1), (4300, 1), (4350, 1), (4400, 1), (4450, 1), (4500, 1), (4550, 1), (4600, 1), (4650, 1), (4700, 1), (4750, 0), (4800, 1), (4850, 1), (4900, 0), (4950, 0), (5000, 0), (5050, 0), (5100, 0), (5150, 0), (5200, 0), (5250, 0), (5300, 1), (5350, 1), (5400, 1), (5450, 1), (5500, 0), (5550, 0), (5600, 0), (5650, 0), (5700, 0), (5750, 0), (5800, 0), (5850, 0), (5900, 0), (5950, 1), (6000, 0), (6050, 0), (6100, 0), (6150, 0), (6200, 0), (6250, 0), (6300, 0), (6350, 1), (6400, 1), (6450, 1), (6500, 1), (6550, 1), (6600, 0), (6650, 0), (6700, 0), (6750, 0), (6800, 0), (6850, 0), (6900, 0), (6950, 0), (7000, 0), (7050, 0), (7100, 0), (7150, 0), (7200, 0), (7250, 0), (7300, 0), (7350, 0), (7400, 0), (7450, 0), (7500, 1), (7550, 1), (7600, 1), (7650, 1), (7700, 0), (7750, 0), (7800, 1), (7850, 0), (7900, 0), (7950, 0), (8000, 0), (8050, 0), (8100, 0), (8150, 0), (8200, 0), (8250, 0), (8300, 0), (8350, 0), (8400, 0), (8450, 1), (8500, 1), (8550, 1), (8600, 1), (8650, 1), (8700, 1), (8750, 1), (8800, 1), (8850, 1), (8900, 1), (8950, 1), (9000, 1), (9050, 1), (9100, 1), (9150, 1), (9200, 1), (9250, 1), (9300, 1), (9350, 1), (9400, 0), (9450, 0), (9500, 0), (9550, 0), (9600, 0), (9650, 0), (9700, 0), (9750, 0), (9800, 0), (9850, 0), (9900, 0), (9950, 0), (10000, 1), (10050, 1), (10100, 1), (10150, 0), (10200, 0), (10250, 0)]
Vdin0_13  din0_13  0 PWL (0n 0.0v 47.49n 0.0v 47.51n 0.0v 97.49n 0.0v 97.51n 0.0v 147.49n 0.0v 147.51n 0.0v 197.49n 0.0v 197.51n 0.0v 247.49n 0.0v 247.51n 0.0v 297.49n 0.0v 297.51n 0.0v 347.49n 0.0v 347.51n 1.8v 397.49n 1.8v 397.51n 1.8v 447.49n 1.8v 447.51n 1.8v 497.49n 1.8v 497.51n 1.8v 547.49n 1.8v 547.51n 1.8v 597.49n 1.8v 597.51n 1.8v 647.49n 1.8v 647.51n 0.0v 697.49n 0.0v 697.51n 0.0v 747.49n 0.0v 747.51n 0.0v 797.49n 0.0v 797.51n 0.0v 847.49n 0.0v 847.51n 0.0v 897.49n 0.0v 897.51n 0.0v 947.49n 0.0v 947.51n 0.0v 997.49n 0.0v 997.51n 0.0v 1047.49n 0.0v 1047.51n 1.8v 1097.49n 1.8v 1097.51n 1.8v 1147.49n 1.8v 1147.51n 1.8v 1197.49n 1.8v 1197.51n 1.8v 1247.49n 1.8v 1247.51n 1.8v 1297.49n 1.8v 1297.51n 1.8v 1347.49n 1.8v 1347.51n 1.8v 1397.49n 1.8v 1397.51n 1.8v 1447.49n 1.8v 1447.51n 1.8v 1497.49n 1.8v 1497.51n 0.0v 1547.49n 0.0v 1547.51n 0.0v 1597.49n 0.0v 1597.51n 1.8v 1647.49n 1.8v 1647.51n 1.8v 1697.49n 1.8v 1697.51n 1.8v 1747.49n 1.8v 1747.51n 1.8v 1797.49n 1.8v 1797.51n 1.8v 1847.49n 1.8v 1847.51n 1.8v 1897.49n 1.8v 1897.51n 1.8v 1947.49n 1.8v 1947.51n 0.0v 1997.49n 0.0v 1997.51n 0.0v 2047.49n 0.0v 2047.51n 0.0v 2097.49n 0.0v 2097.51n 0.0v 2147.49n 0.0v 2147.51n 0.0v 2197.49n 0.0v 2197.51n 0.0v 2247.49n 0.0v 2247.51n 0.0v 2297.49n 0.0v 2297.51n 0.0v 2347.49n 0.0v 2347.51n 0.0v 2397.49n 0.0v 2397.51n 0.0v 2447.49n 0.0v 2447.51n 0.0v 2497.49n 0.0v 2497.51n 0.0v 2547.49n 0.0v 2547.51n 0.0v 2597.49n 0.0v 2597.51n 0.0v 2647.49n 0.0v 2647.51n 0.0v 2697.49n 0.0v 2697.51n 0.0v 2747.49n 0.0v 2747.51n 0.0v 2797.49n 0.0v 2797.51n 0.0v 2847.49n 0.0v 2847.51n 1.8v 2897.49n 1.8v 2897.51n 1.8v 2947.49n 1.8v 2947.51n 1.8v 2997.49n 1.8v 2997.51n 1.8v 3047.49n 1.8v 3047.51n 1.8v 3097.49n 1.8v 3097.51n 1.8v 3147.49n 1.8v 3147.51n 1.8v 3197.49n 1.8v 3197.51n 1.8v 3247.49n 1.8v 3247.51n 1.8v 3297.49n 1.8v 3297.51n 1.8v 3347.49n 1.8v 3347.51n 1.8v 3397.49n 1.8v 3397.51n 1.8v 3447.49n 1.8v 3447.51n 0.0v 3497.49n 0.0v 3497.51n 0.0v 3547.49n 0.0v 3547.51n 0.0v 3597.49n 0.0v 3597.51n 0.0v 3647.49n 0.0v 3647.51n 1.8v 3697.49n 1.8v 3697.51n 1.8v 3747.49n 1.8v 3747.51n 1.8v 3797.49n 1.8v 3797.51n 1.8v 3847.49n 1.8v 3847.51n 1.8v 3897.49n 1.8v 3897.51n 1.8v 3947.49n 1.8v 3947.51n 1.8v 3997.49n 1.8v 3997.51n 1.8v 4047.49n 1.8v 4047.51n 1.8v 4097.49n 1.8v 4097.51n 1.8v 4147.49n 1.8v 4147.51n 1.8v 4197.49n 1.8v 4197.51n 1.8v 4247.49n 1.8v 4247.51n 1.8v 4297.49n 1.8v 4297.51n 1.8v 4347.49n 1.8v 4347.51n 1.8v 4397.49n 1.8v 4397.51n 1.8v 4447.49n 1.8v 4447.51n 1.8v 4497.49n 1.8v 4497.51n 1.8v 4547.49n 1.8v 4547.51n 1.8v 4597.49n 1.8v 4597.51n 1.8v 4647.49n 1.8v 4647.51n 1.8v 4697.49n 1.8v 4697.51n 1.8v 4747.49n 1.8v 4747.51n 0.0v 4797.49n 0.0v 4797.51n 1.8v 4847.49n 1.8v 4847.51n 1.8v 4897.49n 1.8v 4897.51n 0.0v 4947.49n 0.0v 4947.51n 0.0v 4997.49n 0.0v 4997.51n 0.0v 5047.49n 0.0v 5047.51n 0.0v 5097.49n 0.0v 5097.51n 0.0v 5147.49n 0.0v 5147.51n 0.0v 5197.49n 0.0v 5197.51n 0.0v 5247.49n 0.0v 5247.51n 0.0v 5297.49n 0.0v 5297.51n 1.8v 5347.49n 1.8v 5347.51n 1.8v 5397.49n 1.8v 5397.51n 1.8v 5447.49n 1.8v 5447.51n 1.8v 5497.49n 1.8v 5497.51n 0.0v 5547.49n 0.0v 5547.51n 0.0v 5597.49n 0.0v 5597.51n 0.0v 5647.49n 0.0v 5647.51n 0.0v 5697.49n 0.0v 5697.51n 0.0v 5747.49n 0.0v 5747.51n 0.0v 5797.49n 0.0v 5797.51n 0.0v 5847.49n 0.0v 5847.51n 0.0v 5897.49n 0.0v 5897.51n 0.0v 5947.49n 0.0v 5947.51n 1.8v 5997.49n 1.8v 5997.51n 0.0v 6047.49n 0.0v 6047.51n 0.0v 6097.49n 0.0v 6097.51n 0.0v 6147.49n 0.0v 6147.51n 0.0v 6197.49n 0.0v 6197.51n 0.0v 6247.49n 0.0v 6247.51n 0.0v 6297.49n 0.0v 6297.51n 0.0v 6347.49n 0.0v 6347.51n 1.8v 6397.49n 1.8v 6397.51n 1.8v 6447.49n 1.8v 6447.51n 1.8v 6497.49n 1.8v 6497.51n 1.8v 6547.49n 1.8v 6547.51n 1.8v 6597.49n 1.8v 6597.51n 0.0v 6647.49n 0.0v 6647.51n 0.0v 6697.49n 0.0v 6697.51n 0.0v 6747.49n 0.0v 6747.51n 0.0v 6797.49n 0.0v 6797.51n 0.0v 6847.49n 0.0v 6847.51n 0.0v 6897.49n 0.0v 6897.51n 0.0v 6947.49n 0.0v 6947.51n 0.0v 6997.49n 0.0v 6997.51n 0.0v 7047.49n 0.0v 7047.51n 0.0v 7097.49n 0.0v 7097.51n 0.0v 7147.49n 0.0v 7147.51n 0.0v 7197.49n 0.0v 7197.51n 0.0v 7247.49n 0.0v 7247.51n 0.0v 7297.49n 0.0v 7297.51n 0.0v 7347.49n 0.0v 7347.51n 0.0v 7397.49n 0.0v 7397.51n 0.0v 7447.49n 0.0v 7447.51n 0.0v 7497.49n 0.0v 7497.51n 1.8v 7547.49n 1.8v 7547.51n 1.8v 7597.49n 1.8v 7597.51n 1.8v 7647.49n 1.8v 7647.51n 1.8v 7697.49n 1.8v 7697.51n 0.0v 7747.49n 0.0v 7747.51n 0.0v 7797.49n 0.0v 7797.51n 1.8v 7847.49n 1.8v 7847.51n 0.0v 7897.49n 0.0v 7897.51n 0.0v 7947.49n 0.0v 7947.51n 0.0v 7997.49n 0.0v 7997.51n 0.0v 8047.49n 0.0v 8047.51n 0.0v 8097.49n 0.0v 8097.51n 0.0v 8147.49n 0.0v 8147.51n 0.0v 8197.49n 0.0v 8197.51n 0.0v 8247.49n 0.0v 8247.51n 0.0v 8297.49n 0.0v 8297.51n 0.0v 8347.49n 0.0v 8347.51n 0.0v 8397.49n 0.0v 8397.51n 0.0v 8447.49n 0.0v 8447.51n 1.8v 8497.49n 1.8v 8497.51n 1.8v 8547.49n 1.8v 8547.51n 1.8v 8597.49n 1.8v 8597.51n 1.8v 8647.49n 1.8v 8647.51n 1.8v 8697.49n 1.8v 8697.51n 1.8v 8747.49n 1.8v 8747.51n 1.8v 8797.49n 1.8v 8797.51n 1.8v 8847.49n 1.8v 8847.51n 1.8v 8897.49n 1.8v 8897.51n 1.8v 8947.49n 1.8v 8947.51n 1.8v 8997.49n 1.8v 8997.51n 1.8v 9047.49n 1.8v 9047.51n 1.8v 9097.49n 1.8v 9097.51n 1.8v 9147.49n 1.8v 9147.51n 1.8v 9197.49n 1.8v 9197.51n 1.8v 9247.49n 1.8v 9247.51n 1.8v 9297.49n 1.8v 9297.51n 1.8v 9347.49n 1.8v 9347.51n 1.8v 9397.49n 1.8v 9397.51n 0.0v 9447.49n 0.0v 9447.51n 0.0v 9497.49n 0.0v 9497.51n 0.0v 9547.49n 0.0v 9547.51n 0.0v 9597.49n 0.0v 9597.51n 0.0v 9647.49n 0.0v 9647.51n 0.0v 9697.49n 0.0v 9697.51n 0.0v 9747.49n 0.0v 9747.51n 0.0v 9797.49n 0.0v 9797.51n 0.0v 9847.49n 0.0v 9847.51n 0.0v 9897.49n 0.0v 9897.51n 0.0v 9947.49n 0.0v 9947.51n 0.0v 9997.49n 0.0v 9997.51n 1.8v 10047.49n 1.8v 10047.51n 1.8v 10097.49n 1.8v 10097.51n 1.8v 10147.49n 1.8v 10147.51n 0.0v 10197.49n 0.0v 10197.51n 0.0v 10247.49n 0.0v 10247.51n 0.0v )
* (time, data): [(0, 0), (50, 0), (100, 1), (150, 0), (200, 0), (250, 0), (300, 0), (350, 1), (400, 1), (450, 0), (500, 0), (550, 0), (600, 0), (650, 1), (700, 1), (750, 1), (800, 1), (850, 1), (900, 1), (950, 1), (1000, 1), (1050, 0), (1100, 0), (1150, 1), (1200, 1), (1250, 1), (1300, 1), (1350, 1), (1400, 1), (1450, 1), (1500, 1), (1550, 1), (1600, 1), (1650, 1), (1700, 1), (1750, 1), (1800, 1), (1850, 1), (1900, 1), (1950, 0), (2000, 0), (2050, 0), (2100, 0), (2150, 0), (2200, 0), (2250, 0), (2300, 0), (2350, 0), (2400, 0), (2450, 0), (2500, 0), (2550, 0), (2600, 0), (2650, 0), (2700, 0), (2750, 0), (2800, 1), (2850, 0), (2900, 0), (2950, 0), (3000, 0), (3050, 0), (3100, 1), (3150, 1), (3200, 1), (3250, 1), (3300, 1), (3350, 1), (3400, 1), (3450, 0), (3500, 0), (3550, 0), (3600, 0), (3650, 1), (3700, 1), (3750, 1), (3800, 1), (3850, 1), (3900, 1), (3950, 1), (4000, 1), (4050, 1), (4100, 1), (4150, 1), (4200, 1), (4250, 1), (4300, 1), (4350, 1), (4400, 1), (4450, 1), (4500, 0), (4550, 0), (4600, 0), (4650, 0), (4700, 0), (4750, 1), (4800, 1), (4850, 1), (4900, 1), (4950, 1), (5000, 1), (5050, 1), (5100, 1), (5150, 1), (5200, 1), (5250, 1), (5300, 1), (5350, 1), (5400, 1), (5450, 1), (5500, 0), (5550, 0), (5600, 0), (5650, 0), (5700, 0), (5750, 0), (5800, 0), (5850, 0), (5900, 0), (5950, 0), (6000, 1), (6050, 1), (6100, 1), (6150, 1), (6200, 1), (6250, 1), (6300, 1), (6350, 1), (6400, 1), (6450, 1), (6500, 1), (6550, 1), (6600, 0), (6650, 0), (6700, 0), (6750, 0), (6800, 0), (6850, 0), (6900, 0), (6950, 0), (7000, 0), (7050, 0), (7100, 0), (7150, 0), (7200, 0), (7250, 0), (7300, 0), (7350, 0), (7400, 0), (7450, 0), (7500, 1), (7550, 1), (7600, 1), (7650, 1), (7700, 0), (7750, 0), (7800, 1), (7850, 0), (7900, 0), (7950, 0), (8000, 0), (8050, 0), (8100, 0), (8150, 0), (8200, 0), (8250, 0), (8300, 0), (8350, 0), (8400, 0), (8450, 0), (8500, 0), (8550, 0), (8600, 0), (8650, 0), (8700, 0), (8750, 0), (8800, 0), (8850, 0), (8900, 0), (8950, 0), (9000, 1), (9050, 0), (9100, 0), (9150, 0), (9200, 0), (9250, 0), (9300, 0), (9350, 0), (9400, 1), (9450, 1), (9500, 1), (9550, 1), (9600, 1), (9650, 1), (9700, 1), (9750, 1), (9800, 1), (9850, 1), (9900, 1), (9950, 1), (10000, 0), (10050, 0), (10100, 0), (10150, 1), (10200, 1), (10250, 1)]
Vdin0_14  din0_14  0 PWL (0n 0.0v 47.49n 0.0v 47.51n 0.0v 97.49n 0.0v 97.51n 1.8v 147.49n 1.8v 147.51n 0.0v 197.49n 0.0v 197.51n 0.0v 247.49n 0.0v 247.51n 0.0v 297.49n 0.0v 297.51n 0.0v 347.49n 0.0v 347.51n 1.8v 397.49n 1.8v 397.51n 1.8v 447.49n 1.8v 447.51n 0.0v 497.49n 0.0v 497.51n 0.0v 547.49n 0.0v 547.51n 0.0v 597.49n 0.0v 597.51n 0.0v 647.49n 0.0v 647.51n 1.8v 697.49n 1.8v 697.51n 1.8v 747.49n 1.8v 747.51n 1.8v 797.49n 1.8v 797.51n 1.8v 847.49n 1.8v 847.51n 1.8v 897.49n 1.8v 897.51n 1.8v 947.49n 1.8v 947.51n 1.8v 997.49n 1.8v 997.51n 1.8v 1047.49n 1.8v 1047.51n 0.0v 1097.49n 0.0v 1097.51n 0.0v 1147.49n 0.0v 1147.51n 1.8v 1197.49n 1.8v 1197.51n 1.8v 1247.49n 1.8v 1247.51n 1.8v 1297.49n 1.8v 1297.51n 1.8v 1347.49n 1.8v 1347.51n 1.8v 1397.49n 1.8v 1397.51n 1.8v 1447.49n 1.8v 1447.51n 1.8v 1497.49n 1.8v 1497.51n 1.8v 1547.49n 1.8v 1547.51n 1.8v 1597.49n 1.8v 1597.51n 1.8v 1647.49n 1.8v 1647.51n 1.8v 1697.49n 1.8v 1697.51n 1.8v 1747.49n 1.8v 1747.51n 1.8v 1797.49n 1.8v 1797.51n 1.8v 1847.49n 1.8v 1847.51n 1.8v 1897.49n 1.8v 1897.51n 1.8v 1947.49n 1.8v 1947.51n 0.0v 1997.49n 0.0v 1997.51n 0.0v 2047.49n 0.0v 2047.51n 0.0v 2097.49n 0.0v 2097.51n 0.0v 2147.49n 0.0v 2147.51n 0.0v 2197.49n 0.0v 2197.51n 0.0v 2247.49n 0.0v 2247.51n 0.0v 2297.49n 0.0v 2297.51n 0.0v 2347.49n 0.0v 2347.51n 0.0v 2397.49n 0.0v 2397.51n 0.0v 2447.49n 0.0v 2447.51n 0.0v 2497.49n 0.0v 2497.51n 0.0v 2547.49n 0.0v 2547.51n 0.0v 2597.49n 0.0v 2597.51n 0.0v 2647.49n 0.0v 2647.51n 0.0v 2697.49n 0.0v 2697.51n 0.0v 2747.49n 0.0v 2747.51n 0.0v 2797.49n 0.0v 2797.51n 1.8v 2847.49n 1.8v 2847.51n 0.0v 2897.49n 0.0v 2897.51n 0.0v 2947.49n 0.0v 2947.51n 0.0v 2997.49n 0.0v 2997.51n 0.0v 3047.49n 0.0v 3047.51n 0.0v 3097.49n 0.0v 3097.51n 1.8v 3147.49n 1.8v 3147.51n 1.8v 3197.49n 1.8v 3197.51n 1.8v 3247.49n 1.8v 3247.51n 1.8v 3297.49n 1.8v 3297.51n 1.8v 3347.49n 1.8v 3347.51n 1.8v 3397.49n 1.8v 3397.51n 1.8v 3447.49n 1.8v 3447.51n 0.0v 3497.49n 0.0v 3497.51n 0.0v 3547.49n 0.0v 3547.51n 0.0v 3597.49n 0.0v 3597.51n 0.0v 3647.49n 0.0v 3647.51n 1.8v 3697.49n 1.8v 3697.51n 1.8v 3747.49n 1.8v 3747.51n 1.8v 3797.49n 1.8v 3797.51n 1.8v 3847.49n 1.8v 3847.51n 1.8v 3897.49n 1.8v 3897.51n 1.8v 3947.49n 1.8v 3947.51n 1.8v 3997.49n 1.8v 3997.51n 1.8v 4047.49n 1.8v 4047.51n 1.8v 4097.49n 1.8v 4097.51n 1.8v 4147.49n 1.8v 4147.51n 1.8v 4197.49n 1.8v 4197.51n 1.8v 4247.49n 1.8v 4247.51n 1.8v 4297.49n 1.8v 4297.51n 1.8v 4347.49n 1.8v 4347.51n 1.8v 4397.49n 1.8v 4397.51n 1.8v 4447.49n 1.8v 4447.51n 1.8v 4497.49n 1.8v 4497.51n 0.0v 4547.49n 0.0v 4547.51n 0.0v 4597.49n 0.0v 4597.51n 0.0v 4647.49n 0.0v 4647.51n 0.0v 4697.49n 0.0v 4697.51n 0.0v 4747.49n 0.0v 4747.51n 1.8v 4797.49n 1.8v 4797.51n 1.8v 4847.49n 1.8v 4847.51n 1.8v 4897.49n 1.8v 4897.51n 1.8v 4947.49n 1.8v 4947.51n 1.8v 4997.49n 1.8v 4997.51n 1.8v 5047.49n 1.8v 5047.51n 1.8v 5097.49n 1.8v 5097.51n 1.8v 5147.49n 1.8v 5147.51n 1.8v 5197.49n 1.8v 5197.51n 1.8v 5247.49n 1.8v 5247.51n 1.8v 5297.49n 1.8v 5297.51n 1.8v 5347.49n 1.8v 5347.51n 1.8v 5397.49n 1.8v 5397.51n 1.8v 5447.49n 1.8v 5447.51n 1.8v 5497.49n 1.8v 5497.51n 0.0v 5547.49n 0.0v 5547.51n 0.0v 5597.49n 0.0v 5597.51n 0.0v 5647.49n 0.0v 5647.51n 0.0v 5697.49n 0.0v 5697.51n 0.0v 5747.49n 0.0v 5747.51n 0.0v 5797.49n 0.0v 5797.51n 0.0v 5847.49n 0.0v 5847.51n 0.0v 5897.49n 0.0v 5897.51n 0.0v 5947.49n 0.0v 5947.51n 0.0v 5997.49n 0.0v 5997.51n 1.8v 6047.49n 1.8v 6047.51n 1.8v 6097.49n 1.8v 6097.51n 1.8v 6147.49n 1.8v 6147.51n 1.8v 6197.49n 1.8v 6197.51n 1.8v 6247.49n 1.8v 6247.51n 1.8v 6297.49n 1.8v 6297.51n 1.8v 6347.49n 1.8v 6347.51n 1.8v 6397.49n 1.8v 6397.51n 1.8v 6447.49n 1.8v 6447.51n 1.8v 6497.49n 1.8v 6497.51n 1.8v 6547.49n 1.8v 6547.51n 1.8v 6597.49n 1.8v 6597.51n 0.0v 6647.49n 0.0v 6647.51n 0.0v 6697.49n 0.0v 6697.51n 0.0v 6747.49n 0.0v 6747.51n 0.0v 6797.49n 0.0v 6797.51n 0.0v 6847.49n 0.0v 6847.51n 0.0v 6897.49n 0.0v 6897.51n 0.0v 6947.49n 0.0v 6947.51n 0.0v 6997.49n 0.0v 6997.51n 0.0v 7047.49n 0.0v 7047.51n 0.0v 7097.49n 0.0v 7097.51n 0.0v 7147.49n 0.0v 7147.51n 0.0v 7197.49n 0.0v 7197.51n 0.0v 7247.49n 0.0v 7247.51n 0.0v 7297.49n 0.0v 7297.51n 0.0v 7347.49n 0.0v 7347.51n 0.0v 7397.49n 0.0v 7397.51n 0.0v 7447.49n 0.0v 7447.51n 0.0v 7497.49n 0.0v 7497.51n 1.8v 7547.49n 1.8v 7547.51n 1.8v 7597.49n 1.8v 7597.51n 1.8v 7647.49n 1.8v 7647.51n 1.8v 7697.49n 1.8v 7697.51n 0.0v 7747.49n 0.0v 7747.51n 0.0v 7797.49n 0.0v 7797.51n 1.8v 7847.49n 1.8v 7847.51n 0.0v 7897.49n 0.0v 7897.51n 0.0v 7947.49n 0.0v 7947.51n 0.0v 7997.49n 0.0v 7997.51n 0.0v 8047.49n 0.0v 8047.51n 0.0v 8097.49n 0.0v 8097.51n 0.0v 8147.49n 0.0v 8147.51n 0.0v 8197.49n 0.0v 8197.51n 0.0v 8247.49n 0.0v 8247.51n 0.0v 8297.49n 0.0v 8297.51n 0.0v 8347.49n 0.0v 8347.51n 0.0v 8397.49n 0.0v 8397.51n 0.0v 8447.49n 0.0v 8447.51n 0.0v 8497.49n 0.0v 8497.51n 0.0v 8547.49n 0.0v 8547.51n 0.0v 8597.49n 0.0v 8597.51n 0.0v 8647.49n 0.0v 8647.51n 0.0v 8697.49n 0.0v 8697.51n 0.0v 8747.49n 0.0v 8747.51n 0.0v 8797.49n 0.0v 8797.51n 0.0v 8847.49n 0.0v 8847.51n 0.0v 8897.49n 0.0v 8897.51n 0.0v 8947.49n 0.0v 8947.51n 0.0v 8997.49n 0.0v 8997.51n 1.8v 9047.49n 1.8v 9047.51n 0.0v 9097.49n 0.0v 9097.51n 0.0v 9147.49n 0.0v 9147.51n 0.0v 9197.49n 0.0v 9197.51n 0.0v 9247.49n 0.0v 9247.51n 0.0v 9297.49n 0.0v 9297.51n 0.0v 9347.49n 0.0v 9347.51n 0.0v 9397.49n 0.0v 9397.51n 1.8v 9447.49n 1.8v 9447.51n 1.8v 9497.49n 1.8v 9497.51n 1.8v 9547.49n 1.8v 9547.51n 1.8v 9597.49n 1.8v 9597.51n 1.8v 9647.49n 1.8v 9647.51n 1.8v 9697.49n 1.8v 9697.51n 1.8v 9747.49n 1.8v 9747.51n 1.8v 9797.49n 1.8v 9797.51n 1.8v 9847.49n 1.8v 9847.51n 1.8v 9897.49n 1.8v 9897.51n 1.8v 9947.49n 1.8v 9947.51n 1.8v 9997.49n 1.8v 9997.51n 0.0v 10047.49n 0.0v 10047.51n 0.0v 10097.49n 0.0v 10097.51n 0.0v 10147.49n 0.0v 10147.51n 1.8v 10197.49n 1.8v 10197.51n 1.8v 10247.49n 1.8v 10247.51n 1.8v )
* (time, data): [(0, 0), (50, 0), (100, 1), (150, 0), (200, 0), (250, 0), (300, 0), (350, 0), (400, 0), (450, 0), (500, 0), (550, 0), (600, 0), (650, 1), (700, 1), (750, 1), (800, 1), (850, 1), (900, 1), (950, 1), (1000, 1), (1050, 0), (1100, 0), (1150, 0), (1200, 0), (1250, 0), (1300, 0), (1350, 0), (1400, 0), (1450, 0), (1500, 1), (1550, 1), (1600, 1), (1650, 1), (1700, 1), (1750, 1), (1800, 1), (1850, 1), (1900, 1), (1950, 0), (2000, 0), (2050, 0), (2100, 0), (2150, 0), (2200, 0), (2250, 0), (2300, 0), (2350, 0), (2400, 0), (2450, 0), (2500, 0), (2550, 0), (2600, 0), (2650, 0), (2700, 0), (2750, 0), (2800, 0), (2850, 0), (2900, 0), (2950, 0), (3000, 0), (3050, 0), (3100, 0), (3150, 0), (3200, 1), (3250, 1), (3300, 1), (3350, 1), (3400, 1), (3450, 1), (3500, 1), (3550, 1), (3600, 1), (3650, 1), (3700, 1), (3750, 1), (3800, 1), (3850, 1), (3900, 1), (3950, 1), (4000, 1), (4050, 1), (4100, 0), (4150, 0), (4200, 0), (4250, 0), (4300, 0), (4350, 0), (4400, 0), (4450, 0), (4500, 1), (4550, 1), (4600, 1), (4650, 1), (4700, 1), (4750, 0), (4800, 0), (4850, 0), (4900, 1), (4950, 1), (5000, 1), (5050, 1), (5100, 1), (5150, 1), (5200, 1), (5250, 1), (5300, 0), (5350, 0), (5400, 0), (5450, 0), (5500, 1), (5550, 1), (5600, 0), (5650, 0), (5700, 0), (5750, 1), (5800, 1), (5850, 1), (5900, 1), (5950, 1), (6000, 0), (6050, 0), (6100, 1), (6150, 1), (6200, 1), (6250, 1), (6300, 1), (6350, 0), (6400, 0), (6450, 0), (6500, 0), (6550, 0), (6600, 1), (6650, 1), (6700, 1), (6750, 1), (6800, 1), (6850, 1), (6900, 1), (6950, 1), (7000, 1), (7050, 1), (7100, 1), (7150, 1), (7200, 1), (7250, 1), (7300, 1), (7350, 1), (7400, 1), (7450, 1), (7500, 1), (7550, 1), (7600, 1), (7650, 1), (7700, 1), (7750, 1), (7800, 0), (7850, 0), (7900, 0), (7950, 0), (8000, 0), (8050, 0), (8100, 0), (8150, 1), (8200, 1), (8250, 1), (8300, 1), (8350, 1), (8400, 1), (8450, 1), (8500, 1), (8550, 1), (8600, 1), (8650, 1), (8700, 1), (8750, 1), (8800, 1), (8850, 1), (8900, 0), (8950, 0), (9000, 1), (9050, 1), (9100, 1), (9150, 1), (9200, 1), (9250, 1), (9300, 1), (9350, 1), (9400, 0), (9450, 0), (9500, 0), (9550, 0), (9600, 0), (9650, 0), (9700, 0), (9750, 0), (9800, 0), (9850, 0), (9900, 0), (9950, 0), (10000, 0), (10050, 0), (10100, 0), (10150, 0), (10200, 0), (10250, 0)]
Vdin0_15  din0_15  0 PWL (0n 0.0v 47.49n 0.0v 47.51n 0.0v 97.49n 0.0v 97.51n 1.8v 147.49n 1.8v 147.51n 0.0v 197.49n 0.0v 197.51n 0.0v 247.49n 0.0v 247.51n 0.0v 297.49n 0.0v 297.51n 0.0v 347.49n 0.0v 347.51n 0.0v 397.49n 0.0v 397.51n 0.0v 447.49n 0.0v 447.51n 0.0v 497.49n 0.0v 497.51n 0.0v 547.49n 0.0v 547.51n 0.0v 597.49n 0.0v 597.51n 0.0v 647.49n 0.0v 647.51n 1.8v 697.49n 1.8v 697.51n 1.8v 747.49n 1.8v 747.51n 1.8v 797.49n 1.8v 797.51n 1.8v 847.49n 1.8v 847.51n 1.8v 897.49n 1.8v 897.51n 1.8v 947.49n 1.8v 947.51n 1.8v 997.49n 1.8v 997.51n 1.8v 1047.49n 1.8v 1047.51n 0.0v 1097.49n 0.0v 1097.51n 0.0v 1147.49n 0.0v 1147.51n 0.0v 1197.49n 0.0v 1197.51n 0.0v 1247.49n 0.0v 1247.51n 0.0v 1297.49n 0.0v 1297.51n 0.0v 1347.49n 0.0v 1347.51n 0.0v 1397.49n 0.0v 1397.51n 0.0v 1447.49n 0.0v 1447.51n 0.0v 1497.49n 0.0v 1497.51n 1.8v 1547.49n 1.8v 1547.51n 1.8v 1597.49n 1.8v 1597.51n 1.8v 1647.49n 1.8v 1647.51n 1.8v 1697.49n 1.8v 1697.51n 1.8v 1747.49n 1.8v 1747.51n 1.8v 1797.49n 1.8v 1797.51n 1.8v 1847.49n 1.8v 1847.51n 1.8v 1897.49n 1.8v 1897.51n 1.8v 1947.49n 1.8v 1947.51n 0.0v 1997.49n 0.0v 1997.51n 0.0v 2047.49n 0.0v 2047.51n 0.0v 2097.49n 0.0v 2097.51n 0.0v 2147.49n 0.0v 2147.51n 0.0v 2197.49n 0.0v 2197.51n 0.0v 2247.49n 0.0v 2247.51n 0.0v 2297.49n 0.0v 2297.51n 0.0v 2347.49n 0.0v 2347.51n 0.0v 2397.49n 0.0v 2397.51n 0.0v 2447.49n 0.0v 2447.51n 0.0v 2497.49n 0.0v 2497.51n 0.0v 2547.49n 0.0v 2547.51n 0.0v 2597.49n 0.0v 2597.51n 0.0v 2647.49n 0.0v 2647.51n 0.0v 2697.49n 0.0v 2697.51n 0.0v 2747.49n 0.0v 2747.51n 0.0v 2797.49n 0.0v 2797.51n 0.0v 2847.49n 0.0v 2847.51n 0.0v 2897.49n 0.0v 2897.51n 0.0v 2947.49n 0.0v 2947.51n 0.0v 2997.49n 0.0v 2997.51n 0.0v 3047.49n 0.0v 3047.51n 0.0v 3097.49n 0.0v 3097.51n 0.0v 3147.49n 0.0v 3147.51n 0.0v 3197.49n 0.0v 3197.51n 1.8v 3247.49n 1.8v 3247.51n 1.8v 3297.49n 1.8v 3297.51n 1.8v 3347.49n 1.8v 3347.51n 1.8v 3397.49n 1.8v 3397.51n 1.8v 3447.49n 1.8v 3447.51n 1.8v 3497.49n 1.8v 3497.51n 1.8v 3547.49n 1.8v 3547.51n 1.8v 3597.49n 1.8v 3597.51n 1.8v 3647.49n 1.8v 3647.51n 1.8v 3697.49n 1.8v 3697.51n 1.8v 3747.49n 1.8v 3747.51n 1.8v 3797.49n 1.8v 3797.51n 1.8v 3847.49n 1.8v 3847.51n 1.8v 3897.49n 1.8v 3897.51n 1.8v 3947.49n 1.8v 3947.51n 1.8v 3997.49n 1.8v 3997.51n 1.8v 4047.49n 1.8v 4047.51n 1.8v 4097.49n 1.8v 4097.51n 0.0v 4147.49n 0.0v 4147.51n 0.0v 4197.49n 0.0v 4197.51n 0.0v 4247.49n 0.0v 4247.51n 0.0v 4297.49n 0.0v 4297.51n 0.0v 4347.49n 0.0v 4347.51n 0.0v 4397.49n 0.0v 4397.51n 0.0v 4447.49n 0.0v 4447.51n 0.0v 4497.49n 0.0v 4497.51n 1.8v 4547.49n 1.8v 4547.51n 1.8v 4597.49n 1.8v 4597.51n 1.8v 4647.49n 1.8v 4647.51n 1.8v 4697.49n 1.8v 4697.51n 1.8v 4747.49n 1.8v 4747.51n 0.0v 4797.49n 0.0v 4797.51n 0.0v 4847.49n 0.0v 4847.51n 0.0v 4897.49n 0.0v 4897.51n 1.8v 4947.49n 1.8v 4947.51n 1.8v 4997.49n 1.8v 4997.51n 1.8v 5047.49n 1.8v 5047.51n 1.8v 5097.49n 1.8v 5097.51n 1.8v 5147.49n 1.8v 5147.51n 1.8v 5197.49n 1.8v 5197.51n 1.8v 5247.49n 1.8v 5247.51n 1.8v 5297.49n 1.8v 5297.51n 0.0v 5347.49n 0.0v 5347.51n 0.0v 5397.49n 0.0v 5397.51n 0.0v 5447.49n 0.0v 5447.51n 0.0v 5497.49n 0.0v 5497.51n 1.8v 5547.49n 1.8v 5547.51n 1.8v 5597.49n 1.8v 5597.51n 0.0v 5647.49n 0.0v 5647.51n 0.0v 5697.49n 0.0v 5697.51n 0.0v 5747.49n 0.0v 5747.51n 1.8v 5797.49n 1.8v 5797.51n 1.8v 5847.49n 1.8v 5847.51n 1.8v 5897.49n 1.8v 5897.51n 1.8v 5947.49n 1.8v 5947.51n 1.8v 5997.49n 1.8v 5997.51n 0.0v 6047.49n 0.0v 6047.51n 0.0v 6097.49n 0.0v 6097.51n 1.8v 6147.49n 1.8v 6147.51n 1.8v 6197.49n 1.8v 6197.51n 1.8v 6247.49n 1.8v 6247.51n 1.8v 6297.49n 1.8v 6297.51n 1.8v 6347.49n 1.8v 6347.51n 0.0v 6397.49n 0.0v 6397.51n 0.0v 6447.49n 0.0v 6447.51n 0.0v 6497.49n 0.0v 6497.51n 0.0v 6547.49n 0.0v 6547.51n 0.0v 6597.49n 0.0v 6597.51n 1.8v 6647.49n 1.8v 6647.51n 1.8v 6697.49n 1.8v 6697.51n 1.8v 6747.49n 1.8v 6747.51n 1.8v 6797.49n 1.8v 6797.51n 1.8v 6847.49n 1.8v 6847.51n 1.8v 6897.49n 1.8v 6897.51n 1.8v 6947.49n 1.8v 6947.51n 1.8v 6997.49n 1.8v 6997.51n 1.8v 7047.49n 1.8v 7047.51n 1.8v 7097.49n 1.8v 7097.51n 1.8v 7147.49n 1.8v 7147.51n 1.8v 7197.49n 1.8v 7197.51n 1.8v 7247.49n 1.8v 7247.51n 1.8v 7297.49n 1.8v 7297.51n 1.8v 7347.49n 1.8v 7347.51n 1.8v 7397.49n 1.8v 7397.51n 1.8v 7447.49n 1.8v 7447.51n 1.8v 7497.49n 1.8v 7497.51n 1.8v 7547.49n 1.8v 7547.51n 1.8v 7597.49n 1.8v 7597.51n 1.8v 7647.49n 1.8v 7647.51n 1.8v 7697.49n 1.8v 7697.51n 1.8v 7747.49n 1.8v 7747.51n 1.8v 7797.49n 1.8v 7797.51n 0.0v 7847.49n 0.0v 7847.51n 0.0v 7897.49n 0.0v 7897.51n 0.0v 7947.49n 0.0v 7947.51n 0.0v 7997.49n 0.0v 7997.51n 0.0v 8047.49n 0.0v 8047.51n 0.0v 8097.49n 0.0v 8097.51n 0.0v 8147.49n 0.0v 8147.51n 1.8v 8197.49n 1.8v 8197.51n 1.8v 8247.49n 1.8v 8247.51n 1.8v 8297.49n 1.8v 8297.51n 1.8v 8347.49n 1.8v 8347.51n 1.8v 8397.49n 1.8v 8397.51n 1.8v 8447.49n 1.8v 8447.51n 1.8v 8497.49n 1.8v 8497.51n 1.8v 8547.49n 1.8v 8547.51n 1.8v 8597.49n 1.8v 8597.51n 1.8v 8647.49n 1.8v 8647.51n 1.8v 8697.49n 1.8v 8697.51n 1.8v 8747.49n 1.8v 8747.51n 1.8v 8797.49n 1.8v 8797.51n 1.8v 8847.49n 1.8v 8847.51n 1.8v 8897.49n 1.8v 8897.51n 0.0v 8947.49n 0.0v 8947.51n 0.0v 8997.49n 0.0v 8997.51n 1.8v 9047.49n 1.8v 9047.51n 1.8v 9097.49n 1.8v 9097.51n 1.8v 9147.49n 1.8v 9147.51n 1.8v 9197.49n 1.8v 9197.51n 1.8v 9247.49n 1.8v 9247.51n 1.8v 9297.49n 1.8v 9297.51n 1.8v 9347.49n 1.8v 9347.51n 1.8v 9397.49n 1.8v 9397.51n 0.0v 9447.49n 0.0v 9447.51n 0.0v 9497.49n 0.0v 9497.51n 0.0v 9547.49n 0.0v 9547.51n 0.0v 9597.49n 0.0v 9597.51n 0.0v 9647.49n 0.0v 9647.51n 0.0v 9697.49n 0.0v 9697.51n 0.0v 9747.49n 0.0v 9747.51n 0.0v 9797.49n 0.0v 9797.51n 0.0v 9847.49n 0.0v 9847.51n 0.0v 9897.49n 0.0v 9897.51n 0.0v 9947.49n 0.0v 9947.51n 0.0v 9997.49n 0.0v 9997.51n 0.0v 10047.49n 0.0v 10047.51n 0.0v 10097.49n 0.0v 10097.51n 0.0v 10147.49n 0.0v 10147.51n 0.0v 10197.49n 0.0v 10197.51n 0.0v 10247.49n 0.0v 10247.51n 0.0v )
* (time, data): [(0, 0), (50, 0), (100, 0), (150, 1), (200, 0), (250, 0), (300, 0), (350, 1), (400, 1), (450, 0), (500, 0), (550, 0), (600, 0), (650, 0), (700, 0), (750, 0), (800, 0), (850, 1), (900, 1), (950, 0), (1000, 0), (1050, 1), (1100, 1), (1150, 0), (1200, 0), (1250, 1), (1300, 1), (1350, 0), (1400, 1), (1450, 0), (1500, 1), (1550, 0), (1600, 1), (1650, 0), (1700, 1), (1750, 1), (1800, 0), (1850, 0), (1900, 0), (1950, 1), (2000, 0), (2050, 1), (2100, 0), (2150, 0), (2200, 0), (2250, 0), (2300, 0), (2350, 0), (2400, 0), (2450, 0), (2500, 0), (2550, 0), (2600, 0), (2650, 1), (2700, 1), (2750, 1), (2800, 0), (2850, 1), (2900, 1), (2950, 1), (3000, 1), (3050, 0), (3100, 1), (3150, 1), (3200, 1), (3250, 1), (3300, 1), (3350, 1), (3400, 0), (3450, 1), (3500, 1), (3550, 1), (3600, 1), (3650, 1), (3700, 0), (3750, 0), (3800, 1), (3850, 1), (3900, 1), (3950, 1), (4000, 1), (4050, 1), (4100, 0), (4150, 0), (4200, 0), (4250, 0), (4300, 1), (4350, 0), (4400, 0), (4450, 0), (4500, 1), (4550, 0), (4600, 0), (4650, 1), (4700, 0), (4750, 1), (4800, 0), (4850, 0), (4900, 0), (4950, 0), (5000, 0), (5050, 0), (5100, 0), (5150, 1), (5200, 1), (5250, 0), (5300, 1), (5350, 1), (5400, 1), (5450, 0), (5500, 0), (5550, 0), (5600, 1), (5650, 1), (5700, 1), (5750, 0), (5800, 0), (5850, 0), (5900, 1), (5950, 0), (6000, 1), (6050, 0), (6100, 1), (6150, 1), (6200, 0), (6250, 1), (6300, 1), (6350, 1), (6400, 0), (6450, 1), (6500, 0), (6550, 0), (6600, 1), (6650, 0), (6700, 0), (6750, 0), (6800, 0), (6850, 0), (6900, 1), (6950, 1), (7000, 1), (7050, 1), (7100, 1), (7150, 1), (7200, 0), (7250, 1), (7300, 1), (7350, 0), (7400, 0), (7450, 0), (7500, 0), (7550, 0), (7600, 1), (7650, 1), (7700, 1), (7750, 1), (7800, 1), (7850, 0), (7900, 0), (7950, 0), (8000, 1), (8050, 0), (8100, 1), (8150, 0), (8200, 1), (8250, 1), (8300, 1), (8350, 1), (8400, 1), (8450, 0), (8500, 0), (8550, 1), (8600, 1), (8650, 1), (8700, 1), (8750, 0), (8800, 1), (8850, 1), (8900, 1), (8950, 0), (9000, 1), (9050, 1), (9100, 1), (9150, 1), (9200, 0), (9250, 0), (9300, 1), (9350, 1), (9400, 1), (9450, 1), (9500, 0), (9550, 1), (9600, 0), (9650, 0), (9700, 1), (9750, 0), (9800, 1), (9850, 0), (9900, 1), (9950, 0), (10000, 1), (10050, 1), (10100, 1), (10150, 0), (10200, 0), (10250, 0)]
Va0_0  a0_0  0 PWL (0n 0.0v 47.49n 0.0v 47.51n 0.0v 97.49n 0.0v 97.51n 0.0v 147.49n 0.0v 147.51n 1.8v 197.49n 1.8v 197.51n 0.0v 247.49n 0.0v 247.51n 0.0v 297.49n 0.0v 297.51n 0.0v 347.49n 0.0v 347.51n 1.8v 397.49n 1.8v 397.51n 1.8v 447.49n 1.8v 447.51n 0.0v 497.49n 0.0v 497.51n 0.0v 547.49n 0.0v 547.51n 0.0v 597.49n 0.0v 597.51n 0.0v 647.49n 0.0v 647.51n 0.0v 697.49n 0.0v 697.51n 0.0v 747.49n 0.0v 747.51n 0.0v 797.49n 0.0v 797.51n 0.0v 847.49n 0.0v 847.51n 1.8v 897.49n 1.8v 897.51n 1.8v 947.49n 1.8v 947.51n 0.0v 997.49n 0.0v 997.51n 0.0v 1047.49n 0.0v 1047.51n 1.8v 1097.49n 1.8v 1097.51n 1.8v 1147.49n 1.8v 1147.51n 0.0v 1197.49n 0.0v 1197.51n 0.0v 1247.49n 0.0v 1247.51n 1.8v 1297.49n 1.8v 1297.51n 1.8v 1347.49n 1.8v 1347.51n 0.0v 1397.49n 0.0v 1397.51n 1.8v 1447.49n 1.8v 1447.51n 0.0v 1497.49n 0.0v 1497.51n 1.8v 1547.49n 1.8v 1547.51n 0.0v 1597.49n 0.0v 1597.51n 1.8v 1647.49n 1.8v 1647.51n 0.0v 1697.49n 0.0v 1697.51n 1.8v 1747.49n 1.8v 1747.51n 1.8v 1797.49n 1.8v 1797.51n 0.0v 1847.49n 0.0v 1847.51n 0.0v 1897.49n 0.0v 1897.51n 0.0v 1947.49n 0.0v 1947.51n 1.8v 1997.49n 1.8v 1997.51n 0.0v 2047.49n 0.0v 2047.51n 1.8v 2097.49n 1.8v 2097.51n 0.0v 2147.49n 0.0v 2147.51n 0.0v 2197.49n 0.0v 2197.51n 0.0v 2247.49n 0.0v 2247.51n 0.0v 2297.49n 0.0v 2297.51n 0.0v 2347.49n 0.0v 2347.51n 0.0v 2397.49n 0.0v 2397.51n 0.0v 2447.49n 0.0v 2447.51n 0.0v 2497.49n 0.0v 2497.51n 0.0v 2547.49n 0.0v 2547.51n 0.0v 2597.49n 0.0v 2597.51n 0.0v 2647.49n 0.0v 2647.51n 1.8v 2697.49n 1.8v 2697.51n 1.8v 2747.49n 1.8v 2747.51n 1.8v 2797.49n 1.8v 2797.51n 0.0v 2847.49n 0.0v 2847.51n 1.8v 2897.49n 1.8v 2897.51n 1.8v 2947.49n 1.8v 2947.51n 1.8v 2997.49n 1.8v 2997.51n 1.8v 3047.49n 1.8v 3047.51n 0.0v 3097.49n 0.0v 3097.51n 1.8v 3147.49n 1.8v 3147.51n 1.8v 3197.49n 1.8v 3197.51n 1.8v 3247.49n 1.8v 3247.51n 1.8v 3297.49n 1.8v 3297.51n 1.8v 3347.49n 1.8v 3347.51n 1.8v 3397.49n 1.8v 3397.51n 0.0v 3447.49n 0.0v 3447.51n 1.8v 3497.49n 1.8v 3497.51n 1.8v 3547.49n 1.8v 3547.51n 1.8v 3597.49n 1.8v 3597.51n 1.8v 3647.49n 1.8v 3647.51n 1.8v 3697.49n 1.8v 3697.51n 0.0v 3747.49n 0.0v 3747.51n 0.0v 3797.49n 0.0v 3797.51n 1.8v 3847.49n 1.8v 3847.51n 1.8v 3897.49n 1.8v 3897.51n 1.8v 3947.49n 1.8v 3947.51n 1.8v 3997.49n 1.8v 3997.51n 1.8v 4047.49n 1.8v 4047.51n 1.8v 4097.49n 1.8v 4097.51n 0.0v 4147.49n 0.0v 4147.51n 0.0v 4197.49n 0.0v 4197.51n 0.0v 4247.49n 0.0v 4247.51n 0.0v 4297.49n 0.0v 4297.51n 1.8v 4347.49n 1.8v 4347.51n 0.0v 4397.49n 0.0v 4397.51n 0.0v 4447.49n 0.0v 4447.51n 0.0v 4497.49n 0.0v 4497.51n 1.8v 4547.49n 1.8v 4547.51n 0.0v 4597.49n 0.0v 4597.51n 0.0v 4647.49n 0.0v 4647.51n 1.8v 4697.49n 1.8v 4697.51n 0.0v 4747.49n 0.0v 4747.51n 1.8v 4797.49n 1.8v 4797.51n 0.0v 4847.49n 0.0v 4847.51n 0.0v 4897.49n 0.0v 4897.51n 0.0v 4947.49n 0.0v 4947.51n 0.0v 4997.49n 0.0v 4997.51n 0.0v 5047.49n 0.0v 5047.51n 0.0v 5097.49n 0.0v 5097.51n 0.0v 5147.49n 0.0v 5147.51n 1.8v 5197.49n 1.8v 5197.51n 1.8v 5247.49n 1.8v 5247.51n 0.0v 5297.49n 0.0v 5297.51n 1.8v 5347.49n 1.8v 5347.51n 1.8v 5397.49n 1.8v 5397.51n 1.8v 5447.49n 1.8v 5447.51n 0.0v 5497.49n 0.0v 5497.51n 0.0v 5547.49n 0.0v 5547.51n 0.0v 5597.49n 0.0v 5597.51n 1.8v 5647.49n 1.8v 5647.51n 1.8v 5697.49n 1.8v 5697.51n 1.8v 5747.49n 1.8v 5747.51n 0.0v 5797.49n 0.0v 5797.51n 0.0v 5847.49n 0.0v 5847.51n 0.0v 5897.49n 0.0v 5897.51n 1.8v 5947.49n 1.8v 5947.51n 0.0v 5997.49n 0.0v 5997.51n 1.8v 6047.49n 1.8v 6047.51n 0.0v 6097.49n 0.0v 6097.51n 1.8v 6147.49n 1.8v 6147.51n 1.8v 6197.49n 1.8v 6197.51n 0.0v 6247.49n 0.0v 6247.51n 1.8v 6297.49n 1.8v 6297.51n 1.8v 6347.49n 1.8v 6347.51n 1.8v 6397.49n 1.8v 6397.51n 0.0v 6447.49n 0.0v 6447.51n 1.8v 6497.49n 1.8v 6497.51n 0.0v 6547.49n 0.0v 6547.51n 0.0v 6597.49n 0.0v 6597.51n 1.8v 6647.49n 1.8v 6647.51n 0.0v 6697.49n 0.0v 6697.51n 0.0v 6747.49n 0.0v 6747.51n 0.0v 6797.49n 0.0v 6797.51n 0.0v 6847.49n 0.0v 6847.51n 0.0v 6897.49n 0.0v 6897.51n 1.8v 6947.49n 1.8v 6947.51n 1.8v 6997.49n 1.8v 6997.51n 1.8v 7047.49n 1.8v 7047.51n 1.8v 7097.49n 1.8v 7097.51n 1.8v 7147.49n 1.8v 7147.51n 1.8v 7197.49n 1.8v 7197.51n 0.0v 7247.49n 0.0v 7247.51n 1.8v 7297.49n 1.8v 7297.51n 1.8v 7347.49n 1.8v 7347.51n 0.0v 7397.49n 0.0v 7397.51n 0.0v 7447.49n 0.0v 7447.51n 0.0v 7497.49n 0.0v 7497.51n 0.0v 7547.49n 0.0v 7547.51n 0.0v 7597.49n 0.0v 7597.51n 1.8v 7647.49n 1.8v 7647.51n 1.8v 7697.49n 1.8v 7697.51n 1.8v 7747.49n 1.8v 7747.51n 1.8v 7797.49n 1.8v 7797.51n 1.8v 7847.49n 1.8v 7847.51n 0.0v 7897.49n 0.0v 7897.51n 0.0v 7947.49n 0.0v 7947.51n 0.0v 7997.49n 0.0v 7997.51n 1.8v 8047.49n 1.8v 8047.51n 0.0v 8097.49n 0.0v 8097.51n 1.8v 8147.49n 1.8v 8147.51n 0.0v 8197.49n 0.0v 8197.51n 1.8v 8247.49n 1.8v 8247.51n 1.8v 8297.49n 1.8v 8297.51n 1.8v 8347.49n 1.8v 8347.51n 1.8v 8397.49n 1.8v 8397.51n 1.8v 8447.49n 1.8v 8447.51n 0.0v 8497.49n 0.0v 8497.51n 0.0v 8547.49n 0.0v 8547.51n 1.8v 8597.49n 1.8v 8597.51n 1.8v 8647.49n 1.8v 8647.51n 1.8v 8697.49n 1.8v 8697.51n 1.8v 8747.49n 1.8v 8747.51n 0.0v 8797.49n 0.0v 8797.51n 1.8v 8847.49n 1.8v 8847.51n 1.8v 8897.49n 1.8v 8897.51n 1.8v 8947.49n 1.8v 8947.51n 0.0v 8997.49n 0.0v 8997.51n 1.8v 9047.49n 1.8v 9047.51n 1.8v 9097.49n 1.8v 9097.51n 1.8v 9147.49n 1.8v 9147.51n 1.8v 9197.49n 1.8v 9197.51n 0.0v 9247.49n 0.0v 9247.51n 0.0v 9297.49n 0.0v 9297.51n 1.8v 9347.49n 1.8v 9347.51n 1.8v 9397.49n 1.8v 9397.51n 1.8v 9447.49n 1.8v 9447.51n 1.8v 9497.49n 1.8v 9497.51n 0.0v 9547.49n 0.0v 9547.51n 1.8v 9597.49n 1.8v 9597.51n 0.0v 9647.49n 0.0v 9647.51n 0.0v 9697.49n 0.0v 9697.51n 1.8v 9747.49n 1.8v 9747.51n 0.0v 9797.49n 0.0v 9797.51n 1.8v 9847.49n 1.8v 9847.51n 0.0v 9897.49n 0.0v 9897.51n 1.8v 9947.49n 1.8v 9947.51n 0.0v 9997.49n 0.0v 9997.51n 1.8v 10047.49n 1.8v 10047.51n 1.8v 10097.49n 1.8v 10097.51n 1.8v 10147.49n 1.8v 10147.51n 0.0v 10197.49n 0.0v 10197.51n 0.0v 10247.49n 0.0v 10247.51n 0.0v )
* (time, data): [(0, 0), (50, 1), (100, 0), (150, 1), (200, 0), (250, 1), (300, 1), (350, 1), (400, 1), (450, 0), (500, 0), (550, 0), (600, 1), (650, 1), (700, 1), (750, 0), (800, 0), (850, 1), (900, 1), (950, 1), (1000, 1), (1050, 0), (1100, 0), (1150, 0), (1200, 0), (1250, 0), (1300, 1), (1350, 0), (1400, 0), (1450, 1), (1500, 1), (1550, 1), (1600, 0), (1650, 0), (1700, 0), (1750, 1), (1800, 1), (1850, 1), (1900, 1), (1950, 1), (2000, 0), (2050, 1), (2100, 1), (2150, 0), (2200, 1), (2250, 0), (2300, 0), (2350, 0), (2400, 1), (2450, 1), (2500, 0), (2550, 1), (2600, 0), (2650, 1), (2700, 1), (2750, 1), (2800, 0), (2850, 1), (2900, 1), (2950, 0), (3000, 0), (3050, 0), (3100, 0), (3150, 0), (3200, 1), (3250, 1), (3300, 1), (3350, 1), (3400, 0), (3450, 1), (3500, 1), (3550, 1), (3600, 1), (3650, 0), (3700, 0), (3750, 0), (3800, 1), (3850, 1), (3900, 0), (3950, 0), (4000, 0), (4050, 0), (4100, 0), (4150, 0), (4200, 0), (4250, 0), (4300, 1), (4350, 1), (4400, 0), (4450, 0), (4500, 0), (4550, 1), (4600, 1), (4650, 0), (4700, 0), (4750, 0), (4800, 0), (4850, 0), (4900, 1), (4950, 0), (5000, 1), (5050, 1), (5100, 1), (5150, 1), (5200, 1), (5250, 1), (5300, 1), (5350, 0), (5400, 0), (5450, 0), (5500, 1), (5550, 1), (5600, 1), (5650, 1), (5700, 1), (5750, 0), (5800, 0), (5850, 0), (5900, 1), (5950, 0), (6000, 1), (6050, 0), (6100, 0), (6150, 1), (6200, 1), (6250, 1), (6300, 1), (6350, 1), (6400, 1), (6450, 0), (6500, 0), (6550, 0), (6600, 0), (6650, 1), (6700, 0), (6750, 0), (6800, 0), (6850, 0), (6900, 0), (6950, 0), (7000, 0), (7050, 0), (7100, 0), (7150, 0), (7200, 0), (7250, 1), (7300, 1), (7350, 1), (7400, 0), (7450, 0), (7500, 0), (7550, 1), (7600, 1), (7650, 1), (7700, 0), (7750, 1), (7800, 0), (7850, 1), (7900, 1), (7950, 0), (8000, 1), (8050, 1), (8100, 1), (8150, 1), (8200, 0), (8250, 0), (8300, 1), (8350, 1), (8400, 1), (8450, 1), (8500, 1), (8550, 1), (8600, 1), (8650, 1), (8700, 0), (8750, 1), (8800, 1), (8850, 0), (8900, 0), (8950, 0), (9000, 0), (9050, 1), (9100, 1), (9150, 1), (9200, 1), (9250, 1), (9300, 1), (9350, 1), (9400, 1), (9450, 1), (9500, 1), (9550, 1), (9600, 0), (9650, 0), (9700, 1), (9750, 1), (9800, 1), (9850, 1), (9900, 0), (9950, 1), (10000, 0), (10050, 0), (10100, 0), (10150, 0), (10200, 0), (10250, 0)]
Va0_1  a0_1  0 PWL (0n 0.0v 47.49n 0.0v 47.51n 1.8v 97.49n 1.8v 97.51n 0.0v 147.49n 0.0v 147.51n 1.8v 197.49n 1.8v 197.51n 0.0v 247.49n 0.0v 247.51n 1.8v 297.49n 1.8v 297.51n 1.8v 347.49n 1.8v 347.51n 1.8v 397.49n 1.8v 397.51n 1.8v 447.49n 1.8v 447.51n 0.0v 497.49n 0.0v 497.51n 0.0v 547.49n 0.0v 547.51n 0.0v 597.49n 0.0v 597.51n 1.8v 647.49n 1.8v 647.51n 1.8v 697.49n 1.8v 697.51n 1.8v 747.49n 1.8v 747.51n 0.0v 797.49n 0.0v 797.51n 0.0v 847.49n 0.0v 847.51n 1.8v 897.49n 1.8v 897.51n 1.8v 947.49n 1.8v 947.51n 1.8v 997.49n 1.8v 997.51n 1.8v 1047.49n 1.8v 1047.51n 0.0v 1097.49n 0.0v 1097.51n 0.0v 1147.49n 0.0v 1147.51n 0.0v 1197.49n 0.0v 1197.51n 0.0v 1247.49n 0.0v 1247.51n 0.0v 1297.49n 0.0v 1297.51n 1.8v 1347.49n 1.8v 1347.51n 0.0v 1397.49n 0.0v 1397.51n 0.0v 1447.49n 0.0v 1447.51n 1.8v 1497.49n 1.8v 1497.51n 1.8v 1547.49n 1.8v 1547.51n 1.8v 1597.49n 1.8v 1597.51n 0.0v 1647.49n 0.0v 1647.51n 0.0v 1697.49n 0.0v 1697.51n 0.0v 1747.49n 0.0v 1747.51n 1.8v 1797.49n 1.8v 1797.51n 1.8v 1847.49n 1.8v 1847.51n 1.8v 1897.49n 1.8v 1897.51n 1.8v 1947.49n 1.8v 1947.51n 1.8v 1997.49n 1.8v 1997.51n 0.0v 2047.49n 0.0v 2047.51n 1.8v 2097.49n 1.8v 2097.51n 1.8v 2147.49n 1.8v 2147.51n 0.0v 2197.49n 0.0v 2197.51n 1.8v 2247.49n 1.8v 2247.51n 0.0v 2297.49n 0.0v 2297.51n 0.0v 2347.49n 0.0v 2347.51n 0.0v 2397.49n 0.0v 2397.51n 1.8v 2447.49n 1.8v 2447.51n 1.8v 2497.49n 1.8v 2497.51n 0.0v 2547.49n 0.0v 2547.51n 1.8v 2597.49n 1.8v 2597.51n 0.0v 2647.49n 0.0v 2647.51n 1.8v 2697.49n 1.8v 2697.51n 1.8v 2747.49n 1.8v 2747.51n 1.8v 2797.49n 1.8v 2797.51n 0.0v 2847.49n 0.0v 2847.51n 1.8v 2897.49n 1.8v 2897.51n 1.8v 2947.49n 1.8v 2947.51n 0.0v 2997.49n 0.0v 2997.51n 0.0v 3047.49n 0.0v 3047.51n 0.0v 3097.49n 0.0v 3097.51n 0.0v 3147.49n 0.0v 3147.51n 0.0v 3197.49n 0.0v 3197.51n 1.8v 3247.49n 1.8v 3247.51n 1.8v 3297.49n 1.8v 3297.51n 1.8v 3347.49n 1.8v 3347.51n 1.8v 3397.49n 1.8v 3397.51n 0.0v 3447.49n 0.0v 3447.51n 1.8v 3497.49n 1.8v 3497.51n 1.8v 3547.49n 1.8v 3547.51n 1.8v 3597.49n 1.8v 3597.51n 1.8v 3647.49n 1.8v 3647.51n 0.0v 3697.49n 0.0v 3697.51n 0.0v 3747.49n 0.0v 3747.51n 0.0v 3797.49n 0.0v 3797.51n 1.8v 3847.49n 1.8v 3847.51n 1.8v 3897.49n 1.8v 3897.51n 0.0v 3947.49n 0.0v 3947.51n 0.0v 3997.49n 0.0v 3997.51n 0.0v 4047.49n 0.0v 4047.51n 0.0v 4097.49n 0.0v 4097.51n 0.0v 4147.49n 0.0v 4147.51n 0.0v 4197.49n 0.0v 4197.51n 0.0v 4247.49n 0.0v 4247.51n 0.0v 4297.49n 0.0v 4297.51n 1.8v 4347.49n 1.8v 4347.51n 1.8v 4397.49n 1.8v 4397.51n 0.0v 4447.49n 0.0v 4447.51n 0.0v 4497.49n 0.0v 4497.51n 0.0v 4547.49n 0.0v 4547.51n 1.8v 4597.49n 1.8v 4597.51n 1.8v 4647.49n 1.8v 4647.51n 0.0v 4697.49n 0.0v 4697.51n 0.0v 4747.49n 0.0v 4747.51n 0.0v 4797.49n 0.0v 4797.51n 0.0v 4847.49n 0.0v 4847.51n 0.0v 4897.49n 0.0v 4897.51n 1.8v 4947.49n 1.8v 4947.51n 0.0v 4997.49n 0.0v 4997.51n 1.8v 5047.49n 1.8v 5047.51n 1.8v 5097.49n 1.8v 5097.51n 1.8v 5147.49n 1.8v 5147.51n 1.8v 5197.49n 1.8v 5197.51n 1.8v 5247.49n 1.8v 5247.51n 1.8v 5297.49n 1.8v 5297.51n 1.8v 5347.49n 1.8v 5347.51n 0.0v 5397.49n 0.0v 5397.51n 0.0v 5447.49n 0.0v 5447.51n 0.0v 5497.49n 0.0v 5497.51n 1.8v 5547.49n 1.8v 5547.51n 1.8v 5597.49n 1.8v 5597.51n 1.8v 5647.49n 1.8v 5647.51n 1.8v 5697.49n 1.8v 5697.51n 1.8v 5747.49n 1.8v 5747.51n 0.0v 5797.49n 0.0v 5797.51n 0.0v 5847.49n 0.0v 5847.51n 0.0v 5897.49n 0.0v 5897.51n 1.8v 5947.49n 1.8v 5947.51n 0.0v 5997.49n 0.0v 5997.51n 1.8v 6047.49n 1.8v 6047.51n 0.0v 6097.49n 0.0v 6097.51n 0.0v 6147.49n 0.0v 6147.51n 1.8v 6197.49n 1.8v 6197.51n 1.8v 6247.49n 1.8v 6247.51n 1.8v 6297.49n 1.8v 6297.51n 1.8v 6347.49n 1.8v 6347.51n 1.8v 6397.49n 1.8v 6397.51n 1.8v 6447.49n 1.8v 6447.51n 0.0v 6497.49n 0.0v 6497.51n 0.0v 6547.49n 0.0v 6547.51n 0.0v 6597.49n 0.0v 6597.51n 0.0v 6647.49n 0.0v 6647.51n 1.8v 6697.49n 1.8v 6697.51n 0.0v 6747.49n 0.0v 6747.51n 0.0v 6797.49n 0.0v 6797.51n 0.0v 6847.49n 0.0v 6847.51n 0.0v 6897.49n 0.0v 6897.51n 0.0v 6947.49n 0.0v 6947.51n 0.0v 6997.49n 0.0v 6997.51n 0.0v 7047.49n 0.0v 7047.51n 0.0v 7097.49n 0.0v 7097.51n 0.0v 7147.49n 0.0v 7147.51n 0.0v 7197.49n 0.0v 7197.51n 0.0v 7247.49n 0.0v 7247.51n 1.8v 7297.49n 1.8v 7297.51n 1.8v 7347.49n 1.8v 7347.51n 1.8v 7397.49n 1.8v 7397.51n 0.0v 7447.49n 0.0v 7447.51n 0.0v 7497.49n 0.0v 7497.51n 0.0v 7547.49n 0.0v 7547.51n 1.8v 7597.49n 1.8v 7597.51n 1.8v 7647.49n 1.8v 7647.51n 1.8v 7697.49n 1.8v 7697.51n 0.0v 7747.49n 0.0v 7747.51n 1.8v 7797.49n 1.8v 7797.51n 0.0v 7847.49n 0.0v 7847.51n 1.8v 7897.49n 1.8v 7897.51n 1.8v 7947.49n 1.8v 7947.51n 0.0v 7997.49n 0.0v 7997.51n 1.8v 8047.49n 1.8v 8047.51n 1.8v 8097.49n 1.8v 8097.51n 1.8v 8147.49n 1.8v 8147.51n 1.8v 8197.49n 1.8v 8197.51n 0.0v 8247.49n 0.0v 8247.51n 0.0v 8297.49n 0.0v 8297.51n 1.8v 8347.49n 1.8v 8347.51n 1.8v 8397.49n 1.8v 8397.51n 1.8v 8447.49n 1.8v 8447.51n 1.8v 8497.49n 1.8v 8497.51n 1.8v 8547.49n 1.8v 8547.51n 1.8v 8597.49n 1.8v 8597.51n 1.8v 8647.49n 1.8v 8647.51n 1.8v 8697.49n 1.8v 8697.51n 0.0v 8747.49n 0.0v 8747.51n 1.8v 8797.49n 1.8v 8797.51n 1.8v 8847.49n 1.8v 8847.51n 0.0v 8897.49n 0.0v 8897.51n 0.0v 8947.49n 0.0v 8947.51n 0.0v 8997.49n 0.0v 8997.51n 0.0v 9047.49n 0.0v 9047.51n 1.8v 9097.49n 1.8v 9097.51n 1.8v 9147.49n 1.8v 9147.51n 1.8v 9197.49n 1.8v 9197.51n 1.8v 9247.49n 1.8v 9247.51n 1.8v 9297.49n 1.8v 9297.51n 1.8v 9347.49n 1.8v 9347.51n 1.8v 9397.49n 1.8v 9397.51n 1.8v 9447.49n 1.8v 9447.51n 1.8v 9497.49n 1.8v 9497.51n 1.8v 9547.49n 1.8v 9547.51n 1.8v 9597.49n 1.8v 9597.51n 0.0v 9647.49n 0.0v 9647.51n 0.0v 9697.49n 0.0v 9697.51n 1.8v 9747.49n 1.8v 9747.51n 1.8v 9797.49n 1.8v 9797.51n 1.8v 9847.49n 1.8v 9847.51n 1.8v 9897.49n 1.8v 9897.51n 0.0v 9947.49n 0.0v 9947.51n 1.8v 9997.49n 1.8v 9997.51n 0.0v 10047.49n 0.0v 10047.51n 0.0v 10097.49n 0.0v 10097.51n 0.0v 10147.49n 0.0v 10147.51n 0.0v 10197.49n 0.0v 10197.51n 0.0v 10247.49n 0.0v 10247.51n 0.0v )
* (time, data): [(0, 0), (50, 1), (100, 0), (150, 1), (200, 0), (250, 1), (300, 1), (350, 0), (400, 1), (450, 0), (500, 0), (550, 0), (600, 1), (650, 0), (700, 0), (750, 0), (800, 0), (850, 0), (900, 1), (950, 0), (1000, 0), (1050, 0), (1100, 0), (1150, 0), (1200, 0), (1250, 0), (1300, 0), (1350, 0), (1400, 0), (1450, 0), (1500, 0), (1550, 1), (1600, 0), (1650, 0), (1700, 0), (1750, 0), (1800, 0), (1850, 0), (1900, 0), (1950, 1), (2000, 0), (2050, 0), (2100, 1), (2150, 0), (2200, 1), (2250, 0), (2300, 0), (2350, 0), (2400, 0), (2450, 0), (2500, 0), (2550, 0), (2600, 0), (2650, 0), (2700, 0), (2750, 0), (2800, 1), (2850, 1), (2900, 1), (2950, 0), (3000, 0), (3050, 0), (3100, 0), (3150, 0), (3200, 1), (3250, 1), (3300, 1), (3350, 1), (3400, 0), (3450, 1), (3500, 1), (3550, 1), (3600, 1), (3650, 0), (3700, 0), (3750, 1), (3800, 0), (3850, 0), (3900, 0), (3950, 0), (4000, 0), (4050, 0), (4100, 1), (4150, 1), (4200, 1), (4250, 1), (4300, 1), (4350, 1), (4400, 1), (4450, 1), (4500, 0), (4550, 0), (4600, 0), (4650, 0), (4700, 0), (4750, 0), (4800, 0), (4850, 0), (4900, 0), (4950, 0), (5000, 1), (5050, 0), (5100, 0), (5150, 1), (5200, 1), (5250, 0), (5300, 1), (5350, 0), (5400, 0), (5450, 0), (5500, 1), (5550, 1), (5600, 1), (5650, 1), (5700, 1), (5750, 0), (5800, 0), (5850, 0), (5900, 0), (5950, 1), (6000, 0), (6050, 0), (6100, 1), (6150, 1), (6200, 1), (6250, 0), (6300, 1), (6350, 0), (6400, 1), (6450, 1), (6500, 0), (6550, 0), (6600, 1), (6650, 1), (6700, 1), (6750, 0), (6800, 0), (6850, 0), (6900, 0), (6950, 0), (7000, 0), (7050, 0), (7100, 0), (7150, 1), (7200, 0), (7250, 0), (7300, 0), (7350, 1), (7400, 0), (7450, 0), (7500, 0), (7550, 1), (7600, 1), (7650, 1), (7700, 1), (7750, 0), (7800, 0), (7850, 1), (7900, 1), (7950, 1), (8000, 1), (8050, 0), (8100, 1), (8150, 1), (8200, 0), (8250, 1), (8300, 1), (8350, 1), (8400, 1), (8450, 1), (8500, 1), (8550, 0), (8600, 0), (8650, 0), (8700, 0), (8750, 0), (8800, 0), (8850, 0), (8900, 0), (8950, 0), (9000, 1), (9050, 1), (9100, 1), (9150, 0), (9200, 1), (9250, 0), (9300, 0), (9350, 0), (9400, 0), (9450, 0), (9500, 1), (9550, 1), (9600, 0), (9650, 0), (9700, 1), (9750, 0), (9800, 0), (9850, 1), (9900, 1), (9950, 1), (10000, 1), (10050, 0), (10100, 1), (10150, 1), (10200, 1), (10250, 1)]
Va0_2  a0_2  0 PWL (0n 0.0v 47.49n 0.0v 47.51n 1.8v 97.49n 1.8v 97.51n 0.0v 147.49n 0.0v 147.51n 1.8v 197.49n 1.8v 197.51n 0.0v 247.49n 0.0v 247.51n 1.8v 297.49n 1.8v 297.51n 1.8v 347.49n 1.8v 347.51n 0.0v 397.49n 0.0v 397.51n 1.8v 447.49n 1.8v 447.51n 0.0v 497.49n 0.0v 497.51n 0.0v 547.49n 0.0v 547.51n 0.0v 597.49n 0.0v 597.51n 1.8v 647.49n 1.8v 647.51n 0.0v 697.49n 0.0v 697.51n 0.0v 747.49n 0.0v 747.51n 0.0v 797.49n 0.0v 797.51n 0.0v 847.49n 0.0v 847.51n 0.0v 897.49n 0.0v 897.51n 1.8v 947.49n 1.8v 947.51n 0.0v 997.49n 0.0v 997.51n 0.0v 1047.49n 0.0v 1047.51n 0.0v 1097.49n 0.0v 1097.51n 0.0v 1147.49n 0.0v 1147.51n 0.0v 1197.49n 0.0v 1197.51n 0.0v 1247.49n 0.0v 1247.51n 0.0v 1297.49n 0.0v 1297.51n 0.0v 1347.49n 0.0v 1347.51n 0.0v 1397.49n 0.0v 1397.51n 0.0v 1447.49n 0.0v 1447.51n 0.0v 1497.49n 0.0v 1497.51n 0.0v 1547.49n 0.0v 1547.51n 1.8v 1597.49n 1.8v 1597.51n 0.0v 1647.49n 0.0v 1647.51n 0.0v 1697.49n 0.0v 1697.51n 0.0v 1747.49n 0.0v 1747.51n 0.0v 1797.49n 0.0v 1797.51n 0.0v 1847.49n 0.0v 1847.51n 0.0v 1897.49n 0.0v 1897.51n 0.0v 1947.49n 0.0v 1947.51n 1.8v 1997.49n 1.8v 1997.51n 0.0v 2047.49n 0.0v 2047.51n 0.0v 2097.49n 0.0v 2097.51n 1.8v 2147.49n 1.8v 2147.51n 0.0v 2197.49n 0.0v 2197.51n 1.8v 2247.49n 1.8v 2247.51n 0.0v 2297.49n 0.0v 2297.51n 0.0v 2347.49n 0.0v 2347.51n 0.0v 2397.49n 0.0v 2397.51n 0.0v 2447.49n 0.0v 2447.51n 0.0v 2497.49n 0.0v 2497.51n 0.0v 2547.49n 0.0v 2547.51n 0.0v 2597.49n 0.0v 2597.51n 0.0v 2647.49n 0.0v 2647.51n 0.0v 2697.49n 0.0v 2697.51n 0.0v 2747.49n 0.0v 2747.51n 0.0v 2797.49n 0.0v 2797.51n 1.8v 2847.49n 1.8v 2847.51n 1.8v 2897.49n 1.8v 2897.51n 1.8v 2947.49n 1.8v 2947.51n 0.0v 2997.49n 0.0v 2997.51n 0.0v 3047.49n 0.0v 3047.51n 0.0v 3097.49n 0.0v 3097.51n 0.0v 3147.49n 0.0v 3147.51n 0.0v 3197.49n 0.0v 3197.51n 1.8v 3247.49n 1.8v 3247.51n 1.8v 3297.49n 1.8v 3297.51n 1.8v 3347.49n 1.8v 3347.51n 1.8v 3397.49n 1.8v 3397.51n 0.0v 3447.49n 0.0v 3447.51n 1.8v 3497.49n 1.8v 3497.51n 1.8v 3547.49n 1.8v 3547.51n 1.8v 3597.49n 1.8v 3597.51n 1.8v 3647.49n 1.8v 3647.51n 0.0v 3697.49n 0.0v 3697.51n 0.0v 3747.49n 0.0v 3747.51n 1.8v 3797.49n 1.8v 3797.51n 0.0v 3847.49n 0.0v 3847.51n 0.0v 3897.49n 0.0v 3897.51n 0.0v 3947.49n 0.0v 3947.51n 0.0v 3997.49n 0.0v 3997.51n 0.0v 4047.49n 0.0v 4047.51n 0.0v 4097.49n 0.0v 4097.51n 1.8v 4147.49n 1.8v 4147.51n 1.8v 4197.49n 1.8v 4197.51n 1.8v 4247.49n 1.8v 4247.51n 1.8v 4297.49n 1.8v 4297.51n 1.8v 4347.49n 1.8v 4347.51n 1.8v 4397.49n 1.8v 4397.51n 1.8v 4447.49n 1.8v 4447.51n 1.8v 4497.49n 1.8v 4497.51n 0.0v 4547.49n 0.0v 4547.51n 0.0v 4597.49n 0.0v 4597.51n 0.0v 4647.49n 0.0v 4647.51n 0.0v 4697.49n 0.0v 4697.51n 0.0v 4747.49n 0.0v 4747.51n 0.0v 4797.49n 0.0v 4797.51n 0.0v 4847.49n 0.0v 4847.51n 0.0v 4897.49n 0.0v 4897.51n 0.0v 4947.49n 0.0v 4947.51n 0.0v 4997.49n 0.0v 4997.51n 1.8v 5047.49n 1.8v 5047.51n 0.0v 5097.49n 0.0v 5097.51n 0.0v 5147.49n 0.0v 5147.51n 1.8v 5197.49n 1.8v 5197.51n 1.8v 5247.49n 1.8v 5247.51n 0.0v 5297.49n 0.0v 5297.51n 1.8v 5347.49n 1.8v 5347.51n 0.0v 5397.49n 0.0v 5397.51n 0.0v 5447.49n 0.0v 5447.51n 0.0v 5497.49n 0.0v 5497.51n 1.8v 5547.49n 1.8v 5547.51n 1.8v 5597.49n 1.8v 5597.51n 1.8v 5647.49n 1.8v 5647.51n 1.8v 5697.49n 1.8v 5697.51n 1.8v 5747.49n 1.8v 5747.51n 0.0v 5797.49n 0.0v 5797.51n 0.0v 5847.49n 0.0v 5847.51n 0.0v 5897.49n 0.0v 5897.51n 0.0v 5947.49n 0.0v 5947.51n 1.8v 5997.49n 1.8v 5997.51n 0.0v 6047.49n 0.0v 6047.51n 0.0v 6097.49n 0.0v 6097.51n 1.8v 6147.49n 1.8v 6147.51n 1.8v 6197.49n 1.8v 6197.51n 1.8v 6247.49n 1.8v 6247.51n 0.0v 6297.49n 0.0v 6297.51n 1.8v 6347.49n 1.8v 6347.51n 0.0v 6397.49n 0.0v 6397.51n 1.8v 6447.49n 1.8v 6447.51n 1.8v 6497.49n 1.8v 6497.51n 0.0v 6547.49n 0.0v 6547.51n 0.0v 6597.49n 0.0v 6597.51n 1.8v 6647.49n 1.8v 6647.51n 1.8v 6697.49n 1.8v 6697.51n 1.8v 6747.49n 1.8v 6747.51n 0.0v 6797.49n 0.0v 6797.51n 0.0v 6847.49n 0.0v 6847.51n 0.0v 6897.49n 0.0v 6897.51n 0.0v 6947.49n 0.0v 6947.51n 0.0v 6997.49n 0.0v 6997.51n 0.0v 7047.49n 0.0v 7047.51n 0.0v 7097.49n 0.0v 7097.51n 0.0v 7147.49n 0.0v 7147.51n 1.8v 7197.49n 1.8v 7197.51n 0.0v 7247.49n 0.0v 7247.51n 0.0v 7297.49n 0.0v 7297.51n 0.0v 7347.49n 0.0v 7347.51n 1.8v 7397.49n 1.8v 7397.51n 0.0v 7447.49n 0.0v 7447.51n 0.0v 7497.49n 0.0v 7497.51n 0.0v 7547.49n 0.0v 7547.51n 1.8v 7597.49n 1.8v 7597.51n 1.8v 7647.49n 1.8v 7647.51n 1.8v 7697.49n 1.8v 7697.51n 1.8v 7747.49n 1.8v 7747.51n 0.0v 7797.49n 0.0v 7797.51n 0.0v 7847.49n 0.0v 7847.51n 1.8v 7897.49n 1.8v 7897.51n 1.8v 7947.49n 1.8v 7947.51n 1.8v 7997.49n 1.8v 7997.51n 1.8v 8047.49n 1.8v 8047.51n 0.0v 8097.49n 0.0v 8097.51n 1.8v 8147.49n 1.8v 8147.51n 1.8v 8197.49n 1.8v 8197.51n 0.0v 8247.49n 0.0v 8247.51n 1.8v 8297.49n 1.8v 8297.51n 1.8v 8347.49n 1.8v 8347.51n 1.8v 8397.49n 1.8v 8397.51n 1.8v 8447.49n 1.8v 8447.51n 1.8v 8497.49n 1.8v 8497.51n 1.8v 8547.49n 1.8v 8547.51n 0.0v 8597.49n 0.0v 8597.51n 0.0v 8647.49n 0.0v 8647.51n 0.0v 8697.49n 0.0v 8697.51n 0.0v 8747.49n 0.0v 8747.51n 0.0v 8797.49n 0.0v 8797.51n 0.0v 8847.49n 0.0v 8847.51n 0.0v 8897.49n 0.0v 8897.51n 0.0v 8947.49n 0.0v 8947.51n 0.0v 8997.49n 0.0v 8997.51n 1.8v 9047.49n 1.8v 9047.51n 1.8v 9097.49n 1.8v 9097.51n 1.8v 9147.49n 1.8v 9147.51n 0.0v 9197.49n 0.0v 9197.51n 1.8v 9247.49n 1.8v 9247.51n 0.0v 9297.49n 0.0v 9297.51n 0.0v 9347.49n 0.0v 9347.51n 0.0v 9397.49n 0.0v 9397.51n 0.0v 9447.49n 0.0v 9447.51n 0.0v 9497.49n 0.0v 9497.51n 1.8v 9547.49n 1.8v 9547.51n 1.8v 9597.49n 1.8v 9597.51n 0.0v 9647.49n 0.0v 9647.51n 0.0v 9697.49n 0.0v 9697.51n 1.8v 9747.49n 1.8v 9747.51n 0.0v 9797.49n 0.0v 9797.51n 0.0v 9847.49n 0.0v 9847.51n 1.8v 9897.49n 1.8v 9897.51n 1.8v 9947.49n 1.8v 9947.51n 1.8v 9997.49n 1.8v 9997.51n 1.8v 10047.49n 1.8v 10047.51n 0.0v 10097.49n 0.0v 10097.51n 1.8v 10147.49n 1.8v 10147.51n 1.8v 10197.49n 1.8v 10197.51n 1.8v 10247.49n 1.8v 10247.51n 1.8v )
* (time, data): [(0, 0), (50, 0), (100, 1), (150, 0), (200, 1), (250, 0), (300, 0), (350, 0), (400, 0), (450, 1), (500, 1), (550, 1), (600, 0), (650, 0), (700, 0), (750, 1), (800, 1), (850, 0), (900, 0), (950, 0), (1000, 0), (1050, 1), (1100, 1), (1150, 1), (1200, 1), (1250, 1), (1300, 0), (1350, 1), (1400, 1), (1450, 0), (1500, 1), (1550, 0), (1600, 1), (1650, 1), (1700, 1), (1750, 0), (1800, 0), (1850, 0), (1900, 0), (1950, 0), (2000, 1), (2050, 1), (2100, 0), (2150, 1), (2200, 0), (2250, 0), (2300, 0), (2350, 0), (2400, 0), (2450, 0), (2500, 1), (2550, 0), (2600, 1), (2650, 0), (2700, 0), (2750, 1), (2800, 1), (2850, 0), (2900, 0), (2950, 1), (3000, 1), (3050, 0), (3100, 0), (3150, 0), (3200, 0), (3250, 0), (3300, 0), (3350, 0), (3400, 0), (3450, 0), (3500, 0), (3550, 0), (3600, 0), (3650, 0), (3700, 0), (3750, 1), (3800, 1), (3850, 1), (3900, 1), (3950, 1), (4000, 1), (4050, 1), (4100, 1), (4150, 1), (4200, 1), (4250, 1), (4300, 0), (4350, 0), (4400, 1), (4450, 1), (4500, 1), (4550, 0), (4600, 0), (4650, 0), (4700, 1), (4750, 0), (4800, 0), (4850, 0), (4900, 1), (4950, 1), (5000, 0), (5050, 0), (5100, 0), (5150, 0), (5200, 0), (5250, 0), (5300, 0), (5350, 0), (5400, 0), (5450, 1), (5500, 1), (5550, 0), (5600, 0), (5650, 0), (5700, 0), (5750, 1), (5800, 1), (5850, 1), (5900, 0), (5950, 0), (6000, 1), (6050, 1), (6100, 1), (6150, 0), (6200, 1), (6250, 1), (6300, 0), (6350, 0), (6400, 0), (6450, 1), (6500, 0), (6550, 1), (6600, 1), (6650, 1), (6700, 0), (6750, 0), (6800, 0), (6850, 0), (6900, 0), (6950, 0), (7000, 1), (7050, 1), (7100, 1), (7150, 1), (7200, 0), (7250, 0), (7300, 0), (7350, 1), (7400, 0), (7450, 1), (7500, 0), (7550, 1), (7600, 0), (7650, 0), (7700, 1), (7750, 0), (7800, 0), (7850, 1), (7900, 0), (7950, 1), (8000, 0), (8050, 1), (8100, 0), (8150, 1), (8200, 1), (8250, 1), (8300, 0), (8350, 0), (8400, 0), (8450, 0), (8500, 0), (8550, 0), (8600, 0), (8650, 1), (8700, 0), (8750, 0), (8800, 1), (8850, 0), (8900, 1), (8950, 1), (9000, 0), (9050, 0), (9100, 0), (9150, 1), (9200, 0), (9250, 0), (9300, 1), (9350, 1), (9400, 1), (9450, 1), (9500, 1), (9550, 0), (9600, 1), (9650, 1), (9700, 0), (9750, 1), (9800, 1), (9850, 0), (9900, 0), (9950, 0), (10000, 1), (10050, 0), (10100, 1), (10150, 1), (10200, 1), (10250, 1)]
Va0_3  a0_3  0 PWL (0n 0.0v 47.49n 0.0v 47.51n 0.0v 97.49n 0.0v 97.51n 1.8v 147.49n 1.8v 147.51n 0.0v 197.49n 0.0v 197.51n 1.8v 247.49n 1.8v 247.51n 0.0v 297.49n 0.0v 297.51n 0.0v 347.49n 0.0v 347.51n 0.0v 397.49n 0.0v 397.51n 0.0v 447.49n 0.0v 447.51n 1.8v 497.49n 1.8v 497.51n 1.8v 547.49n 1.8v 547.51n 1.8v 597.49n 1.8v 597.51n 0.0v 647.49n 0.0v 647.51n 0.0v 697.49n 0.0v 697.51n 0.0v 747.49n 0.0v 747.51n 1.8v 797.49n 1.8v 797.51n 1.8v 847.49n 1.8v 847.51n 0.0v 897.49n 0.0v 897.51n 0.0v 947.49n 0.0v 947.51n 0.0v 997.49n 0.0v 997.51n 0.0v 1047.49n 0.0v 1047.51n 1.8v 1097.49n 1.8v 1097.51n 1.8v 1147.49n 1.8v 1147.51n 1.8v 1197.49n 1.8v 1197.51n 1.8v 1247.49n 1.8v 1247.51n 1.8v 1297.49n 1.8v 1297.51n 0.0v 1347.49n 0.0v 1347.51n 1.8v 1397.49n 1.8v 1397.51n 1.8v 1447.49n 1.8v 1447.51n 0.0v 1497.49n 0.0v 1497.51n 1.8v 1547.49n 1.8v 1547.51n 0.0v 1597.49n 0.0v 1597.51n 1.8v 1647.49n 1.8v 1647.51n 1.8v 1697.49n 1.8v 1697.51n 1.8v 1747.49n 1.8v 1747.51n 0.0v 1797.49n 0.0v 1797.51n 0.0v 1847.49n 0.0v 1847.51n 0.0v 1897.49n 0.0v 1897.51n 0.0v 1947.49n 0.0v 1947.51n 0.0v 1997.49n 0.0v 1997.51n 1.8v 2047.49n 1.8v 2047.51n 1.8v 2097.49n 1.8v 2097.51n 0.0v 2147.49n 0.0v 2147.51n 1.8v 2197.49n 1.8v 2197.51n 0.0v 2247.49n 0.0v 2247.51n 0.0v 2297.49n 0.0v 2297.51n 0.0v 2347.49n 0.0v 2347.51n 0.0v 2397.49n 0.0v 2397.51n 0.0v 2447.49n 0.0v 2447.51n 0.0v 2497.49n 0.0v 2497.51n 1.8v 2547.49n 1.8v 2547.51n 0.0v 2597.49n 0.0v 2597.51n 1.8v 2647.49n 1.8v 2647.51n 0.0v 2697.49n 0.0v 2697.51n 0.0v 2747.49n 0.0v 2747.51n 1.8v 2797.49n 1.8v 2797.51n 1.8v 2847.49n 1.8v 2847.51n 0.0v 2897.49n 0.0v 2897.51n 0.0v 2947.49n 0.0v 2947.51n 1.8v 2997.49n 1.8v 2997.51n 1.8v 3047.49n 1.8v 3047.51n 0.0v 3097.49n 0.0v 3097.51n 0.0v 3147.49n 0.0v 3147.51n 0.0v 3197.49n 0.0v 3197.51n 0.0v 3247.49n 0.0v 3247.51n 0.0v 3297.49n 0.0v 3297.51n 0.0v 3347.49n 0.0v 3347.51n 0.0v 3397.49n 0.0v 3397.51n 0.0v 3447.49n 0.0v 3447.51n 0.0v 3497.49n 0.0v 3497.51n 0.0v 3547.49n 0.0v 3547.51n 0.0v 3597.49n 0.0v 3597.51n 0.0v 3647.49n 0.0v 3647.51n 0.0v 3697.49n 0.0v 3697.51n 0.0v 3747.49n 0.0v 3747.51n 1.8v 3797.49n 1.8v 3797.51n 1.8v 3847.49n 1.8v 3847.51n 1.8v 3897.49n 1.8v 3897.51n 1.8v 3947.49n 1.8v 3947.51n 1.8v 3997.49n 1.8v 3997.51n 1.8v 4047.49n 1.8v 4047.51n 1.8v 4097.49n 1.8v 4097.51n 1.8v 4147.49n 1.8v 4147.51n 1.8v 4197.49n 1.8v 4197.51n 1.8v 4247.49n 1.8v 4247.51n 1.8v 4297.49n 1.8v 4297.51n 0.0v 4347.49n 0.0v 4347.51n 0.0v 4397.49n 0.0v 4397.51n 1.8v 4447.49n 1.8v 4447.51n 1.8v 4497.49n 1.8v 4497.51n 1.8v 4547.49n 1.8v 4547.51n 0.0v 4597.49n 0.0v 4597.51n 0.0v 4647.49n 0.0v 4647.51n 0.0v 4697.49n 0.0v 4697.51n 1.8v 4747.49n 1.8v 4747.51n 0.0v 4797.49n 0.0v 4797.51n 0.0v 4847.49n 0.0v 4847.51n 0.0v 4897.49n 0.0v 4897.51n 1.8v 4947.49n 1.8v 4947.51n 1.8v 4997.49n 1.8v 4997.51n 0.0v 5047.49n 0.0v 5047.51n 0.0v 5097.49n 0.0v 5097.51n 0.0v 5147.49n 0.0v 5147.51n 0.0v 5197.49n 0.0v 5197.51n 0.0v 5247.49n 0.0v 5247.51n 0.0v 5297.49n 0.0v 5297.51n 0.0v 5347.49n 0.0v 5347.51n 0.0v 5397.49n 0.0v 5397.51n 0.0v 5447.49n 0.0v 5447.51n 1.8v 5497.49n 1.8v 5497.51n 1.8v 5547.49n 1.8v 5547.51n 0.0v 5597.49n 0.0v 5597.51n 0.0v 5647.49n 0.0v 5647.51n 0.0v 5697.49n 0.0v 5697.51n 0.0v 5747.49n 0.0v 5747.51n 1.8v 5797.49n 1.8v 5797.51n 1.8v 5847.49n 1.8v 5847.51n 1.8v 5897.49n 1.8v 5897.51n 0.0v 5947.49n 0.0v 5947.51n 0.0v 5997.49n 0.0v 5997.51n 1.8v 6047.49n 1.8v 6047.51n 1.8v 6097.49n 1.8v 6097.51n 1.8v 6147.49n 1.8v 6147.51n 0.0v 6197.49n 0.0v 6197.51n 1.8v 6247.49n 1.8v 6247.51n 1.8v 6297.49n 1.8v 6297.51n 0.0v 6347.49n 0.0v 6347.51n 0.0v 6397.49n 0.0v 6397.51n 0.0v 6447.49n 0.0v 6447.51n 1.8v 6497.49n 1.8v 6497.51n 0.0v 6547.49n 0.0v 6547.51n 1.8v 6597.49n 1.8v 6597.51n 1.8v 6647.49n 1.8v 6647.51n 1.8v 6697.49n 1.8v 6697.51n 0.0v 6747.49n 0.0v 6747.51n 0.0v 6797.49n 0.0v 6797.51n 0.0v 6847.49n 0.0v 6847.51n 0.0v 6897.49n 0.0v 6897.51n 0.0v 6947.49n 0.0v 6947.51n 0.0v 6997.49n 0.0v 6997.51n 1.8v 7047.49n 1.8v 7047.51n 1.8v 7097.49n 1.8v 7097.51n 1.8v 7147.49n 1.8v 7147.51n 1.8v 7197.49n 1.8v 7197.51n 0.0v 7247.49n 0.0v 7247.51n 0.0v 7297.49n 0.0v 7297.51n 0.0v 7347.49n 0.0v 7347.51n 1.8v 7397.49n 1.8v 7397.51n 0.0v 7447.49n 0.0v 7447.51n 1.8v 7497.49n 1.8v 7497.51n 0.0v 7547.49n 0.0v 7547.51n 1.8v 7597.49n 1.8v 7597.51n 0.0v 7647.49n 0.0v 7647.51n 0.0v 7697.49n 0.0v 7697.51n 1.8v 7747.49n 1.8v 7747.51n 0.0v 7797.49n 0.0v 7797.51n 0.0v 7847.49n 0.0v 7847.51n 1.8v 7897.49n 1.8v 7897.51n 0.0v 7947.49n 0.0v 7947.51n 1.8v 7997.49n 1.8v 7997.51n 0.0v 8047.49n 0.0v 8047.51n 1.8v 8097.49n 1.8v 8097.51n 0.0v 8147.49n 0.0v 8147.51n 1.8v 8197.49n 1.8v 8197.51n 1.8v 8247.49n 1.8v 8247.51n 1.8v 8297.49n 1.8v 8297.51n 0.0v 8347.49n 0.0v 8347.51n 0.0v 8397.49n 0.0v 8397.51n 0.0v 8447.49n 0.0v 8447.51n 0.0v 8497.49n 0.0v 8497.51n 0.0v 8547.49n 0.0v 8547.51n 0.0v 8597.49n 0.0v 8597.51n 0.0v 8647.49n 0.0v 8647.51n 1.8v 8697.49n 1.8v 8697.51n 0.0v 8747.49n 0.0v 8747.51n 0.0v 8797.49n 0.0v 8797.51n 1.8v 8847.49n 1.8v 8847.51n 0.0v 8897.49n 0.0v 8897.51n 1.8v 8947.49n 1.8v 8947.51n 1.8v 8997.49n 1.8v 8997.51n 0.0v 9047.49n 0.0v 9047.51n 0.0v 9097.49n 0.0v 9097.51n 0.0v 9147.49n 0.0v 9147.51n 1.8v 9197.49n 1.8v 9197.51n 0.0v 9247.49n 0.0v 9247.51n 0.0v 9297.49n 0.0v 9297.51n 1.8v 9347.49n 1.8v 9347.51n 1.8v 9397.49n 1.8v 9397.51n 1.8v 9447.49n 1.8v 9447.51n 1.8v 9497.49n 1.8v 9497.51n 1.8v 9547.49n 1.8v 9547.51n 0.0v 9597.49n 0.0v 9597.51n 1.8v 9647.49n 1.8v 9647.51n 1.8v 9697.49n 1.8v 9697.51n 0.0v 9747.49n 0.0v 9747.51n 1.8v 9797.49n 1.8v 9797.51n 1.8v 9847.49n 1.8v 9847.51n 0.0v 9897.49n 0.0v 9897.51n 0.0v 9947.49n 0.0v 9947.51n 0.0v 9997.49n 0.0v 9997.51n 1.8v 10047.49n 1.8v 10047.51n 0.0v 10097.49n 0.0v 10097.51n 1.8v 10147.49n 1.8v 10147.51n 1.8v 10197.49n 1.8v 10197.51n 1.8v 10247.49n 1.8v 10247.51n 1.8v )
* (time, data): [(0, 0), (50, 0), (100, 1), (150, 1), (200, 1), (250, 0), (300, 0), (350, 0), (400, 1), (450, 1), (500, 1), (550, 1), (600, 0), (650, 0), (700, 0), (750, 1), (800, 1), (850, 0), (900, 1), (950, 0), (1000, 0), (1050, 1), (1100, 1), (1150, 1), (1200, 1), (1250, 1), (1300, 0), (1350, 1), (1400, 1), (1450, 0), (1500, 1), (1550, 0), (1600, 1), (1650, 1), (1700, 1), (1750, 0), (1800, 0), (1850, 0), (1900, 0), (1950, 1), (2000, 1), (2050, 1), (2100, 0), (2150, 1), (2200, 0), (2250, 0), (2300, 0), (2350, 0), (2400, 0), (2450, 0), (2500, 1), (2550, 0), (2600, 1), (2650, 0), (2700, 0), (2750, 1), (2800, 1), (2850, 0), (2900, 0), (2950, 1), (3000, 1), (3050, 0), (3100, 0), (3150, 0), (3200, 0), (3250, 0), (3300, 0), (3350, 0), (3400, 0), (3450, 1), (3500, 1), (3550, 1), (3600, 1), (3650, 0), (3700, 0), (3750, 1), (3800, 1), (3850, 1), (3900, 1), (3950, 1), (4000, 1), (4050, 1), (4100, 1), (4150, 1), (4200, 1), (4250, 1), (4300, 0), (4350, 0), (4400, 1), (4450, 1), (4500, 1), (4550, 0), (4600, 0), (4650, 0), (4700, 1), (4750, 0), (4800, 0), (4850, 0), (4900, 1), (4950, 1), (5000, 0), (5050, 0), (5100, 0), (5150, 1), (5200, 1), (5250, 0), (5300, 0), (5350, 0), (5400, 0), (5450, 1), (5500, 1), (5550, 0), (5600, 0), (5650, 0), (5700, 0), (5750, 1), (5800, 1), (5850, 1), (5900, 0), (5950, 0), (6000, 1), (6050, 1), (6100, 1), (6150, 0), (6200, 1), (6250, 1), (6300, 0), (6350, 0), (6400, 0), (6450, 1), (6500, 0), (6550, 1), (6600, 1), (6650, 1), (6700, 0), (6750, 0), (6800, 0), (6850, 0), (6900, 0), (6950, 0), (7000, 1), (7050, 1), (7100, 1), (7150, 1), (7200, 0), (7250, 0), (7300, 0), (7350, 1), (7400, 0), (7450, 1), (7500, 0), (7550, 1), (7600, 0), (7650, 1), (7700, 1), (7750, 0), (7800, 0), (7850, 1), (7900, 0), (7950, 1), (8000, 0), (8050, 1), (8100, 0), (8150, 1), (8200, 1), (8250, 1), (8300, 0), (8350, 0), (8400, 0), (8450, 0), (8500, 0), (8550, 0), (8600, 0), (8650, 1), (8700, 0), (8750, 0), (8800, 1), (8850, 0), (8900, 1), (8950, 1), (9000, 0), (9050, 0), (9100, 0), (9150, 1), (9200, 0), (9250, 0), (9300, 1), (9350, 1), (9400, 1), (9450, 1), (9500, 1), (9550, 1), (9600, 1), (9650, 1), (9700, 1), (9750, 1), (9800, 1), (9850, 0), (9900, 0), (9950, 0), (10000, 1), (10050, 0), (10100, 1), (10150, 1), (10200, 1), (10250, 1)]
Va0_4  a0_4  0 PWL (0n 0.0v 47.49n 0.0v 47.51n 0.0v 97.49n 0.0v 97.51n 1.8v 147.49n 1.8v 147.51n 1.8v 197.49n 1.8v 197.51n 1.8v 247.49n 1.8v 247.51n 0.0v 297.49n 0.0v 297.51n 0.0v 347.49n 0.0v 347.51n 0.0v 397.49n 0.0v 397.51n 1.8v 447.49n 1.8v 447.51n 1.8v 497.49n 1.8v 497.51n 1.8v 547.49n 1.8v 547.51n 1.8v 597.49n 1.8v 597.51n 0.0v 647.49n 0.0v 647.51n 0.0v 697.49n 0.0v 697.51n 0.0v 747.49n 0.0v 747.51n 1.8v 797.49n 1.8v 797.51n 1.8v 847.49n 1.8v 847.51n 0.0v 897.49n 0.0v 897.51n 1.8v 947.49n 1.8v 947.51n 0.0v 997.49n 0.0v 997.51n 0.0v 1047.49n 0.0v 1047.51n 1.8v 1097.49n 1.8v 1097.51n 1.8v 1147.49n 1.8v 1147.51n 1.8v 1197.49n 1.8v 1197.51n 1.8v 1247.49n 1.8v 1247.51n 1.8v 1297.49n 1.8v 1297.51n 0.0v 1347.49n 0.0v 1347.51n 1.8v 1397.49n 1.8v 1397.51n 1.8v 1447.49n 1.8v 1447.51n 0.0v 1497.49n 0.0v 1497.51n 1.8v 1547.49n 1.8v 1547.51n 0.0v 1597.49n 0.0v 1597.51n 1.8v 1647.49n 1.8v 1647.51n 1.8v 1697.49n 1.8v 1697.51n 1.8v 1747.49n 1.8v 1747.51n 0.0v 1797.49n 0.0v 1797.51n 0.0v 1847.49n 0.0v 1847.51n 0.0v 1897.49n 0.0v 1897.51n 0.0v 1947.49n 0.0v 1947.51n 1.8v 1997.49n 1.8v 1997.51n 1.8v 2047.49n 1.8v 2047.51n 1.8v 2097.49n 1.8v 2097.51n 0.0v 2147.49n 0.0v 2147.51n 1.8v 2197.49n 1.8v 2197.51n 0.0v 2247.49n 0.0v 2247.51n 0.0v 2297.49n 0.0v 2297.51n 0.0v 2347.49n 0.0v 2347.51n 0.0v 2397.49n 0.0v 2397.51n 0.0v 2447.49n 0.0v 2447.51n 0.0v 2497.49n 0.0v 2497.51n 1.8v 2547.49n 1.8v 2547.51n 0.0v 2597.49n 0.0v 2597.51n 1.8v 2647.49n 1.8v 2647.51n 0.0v 2697.49n 0.0v 2697.51n 0.0v 2747.49n 0.0v 2747.51n 1.8v 2797.49n 1.8v 2797.51n 1.8v 2847.49n 1.8v 2847.51n 0.0v 2897.49n 0.0v 2897.51n 0.0v 2947.49n 0.0v 2947.51n 1.8v 2997.49n 1.8v 2997.51n 1.8v 3047.49n 1.8v 3047.51n 0.0v 3097.49n 0.0v 3097.51n 0.0v 3147.49n 0.0v 3147.51n 0.0v 3197.49n 0.0v 3197.51n 0.0v 3247.49n 0.0v 3247.51n 0.0v 3297.49n 0.0v 3297.51n 0.0v 3347.49n 0.0v 3347.51n 0.0v 3397.49n 0.0v 3397.51n 0.0v 3447.49n 0.0v 3447.51n 1.8v 3497.49n 1.8v 3497.51n 1.8v 3547.49n 1.8v 3547.51n 1.8v 3597.49n 1.8v 3597.51n 1.8v 3647.49n 1.8v 3647.51n 0.0v 3697.49n 0.0v 3697.51n 0.0v 3747.49n 0.0v 3747.51n 1.8v 3797.49n 1.8v 3797.51n 1.8v 3847.49n 1.8v 3847.51n 1.8v 3897.49n 1.8v 3897.51n 1.8v 3947.49n 1.8v 3947.51n 1.8v 3997.49n 1.8v 3997.51n 1.8v 4047.49n 1.8v 4047.51n 1.8v 4097.49n 1.8v 4097.51n 1.8v 4147.49n 1.8v 4147.51n 1.8v 4197.49n 1.8v 4197.51n 1.8v 4247.49n 1.8v 4247.51n 1.8v 4297.49n 1.8v 4297.51n 0.0v 4347.49n 0.0v 4347.51n 0.0v 4397.49n 0.0v 4397.51n 1.8v 4447.49n 1.8v 4447.51n 1.8v 4497.49n 1.8v 4497.51n 1.8v 4547.49n 1.8v 4547.51n 0.0v 4597.49n 0.0v 4597.51n 0.0v 4647.49n 0.0v 4647.51n 0.0v 4697.49n 0.0v 4697.51n 1.8v 4747.49n 1.8v 4747.51n 0.0v 4797.49n 0.0v 4797.51n 0.0v 4847.49n 0.0v 4847.51n 0.0v 4897.49n 0.0v 4897.51n 1.8v 4947.49n 1.8v 4947.51n 1.8v 4997.49n 1.8v 4997.51n 0.0v 5047.49n 0.0v 5047.51n 0.0v 5097.49n 0.0v 5097.51n 0.0v 5147.49n 0.0v 5147.51n 1.8v 5197.49n 1.8v 5197.51n 1.8v 5247.49n 1.8v 5247.51n 0.0v 5297.49n 0.0v 5297.51n 0.0v 5347.49n 0.0v 5347.51n 0.0v 5397.49n 0.0v 5397.51n 0.0v 5447.49n 0.0v 5447.51n 1.8v 5497.49n 1.8v 5497.51n 1.8v 5547.49n 1.8v 5547.51n 0.0v 5597.49n 0.0v 5597.51n 0.0v 5647.49n 0.0v 5647.51n 0.0v 5697.49n 0.0v 5697.51n 0.0v 5747.49n 0.0v 5747.51n 1.8v 5797.49n 1.8v 5797.51n 1.8v 5847.49n 1.8v 5847.51n 1.8v 5897.49n 1.8v 5897.51n 0.0v 5947.49n 0.0v 5947.51n 0.0v 5997.49n 0.0v 5997.51n 1.8v 6047.49n 1.8v 6047.51n 1.8v 6097.49n 1.8v 6097.51n 1.8v 6147.49n 1.8v 6147.51n 0.0v 6197.49n 0.0v 6197.51n 1.8v 6247.49n 1.8v 6247.51n 1.8v 6297.49n 1.8v 6297.51n 0.0v 6347.49n 0.0v 6347.51n 0.0v 6397.49n 0.0v 6397.51n 0.0v 6447.49n 0.0v 6447.51n 1.8v 6497.49n 1.8v 6497.51n 0.0v 6547.49n 0.0v 6547.51n 1.8v 6597.49n 1.8v 6597.51n 1.8v 6647.49n 1.8v 6647.51n 1.8v 6697.49n 1.8v 6697.51n 0.0v 6747.49n 0.0v 6747.51n 0.0v 6797.49n 0.0v 6797.51n 0.0v 6847.49n 0.0v 6847.51n 0.0v 6897.49n 0.0v 6897.51n 0.0v 6947.49n 0.0v 6947.51n 0.0v 6997.49n 0.0v 6997.51n 1.8v 7047.49n 1.8v 7047.51n 1.8v 7097.49n 1.8v 7097.51n 1.8v 7147.49n 1.8v 7147.51n 1.8v 7197.49n 1.8v 7197.51n 0.0v 7247.49n 0.0v 7247.51n 0.0v 7297.49n 0.0v 7297.51n 0.0v 7347.49n 0.0v 7347.51n 1.8v 7397.49n 1.8v 7397.51n 0.0v 7447.49n 0.0v 7447.51n 1.8v 7497.49n 1.8v 7497.51n 0.0v 7547.49n 0.0v 7547.51n 1.8v 7597.49n 1.8v 7597.51n 0.0v 7647.49n 0.0v 7647.51n 1.8v 7697.49n 1.8v 7697.51n 1.8v 7747.49n 1.8v 7747.51n 0.0v 7797.49n 0.0v 7797.51n 0.0v 7847.49n 0.0v 7847.51n 1.8v 7897.49n 1.8v 7897.51n 0.0v 7947.49n 0.0v 7947.51n 1.8v 7997.49n 1.8v 7997.51n 0.0v 8047.49n 0.0v 8047.51n 1.8v 8097.49n 1.8v 8097.51n 0.0v 8147.49n 0.0v 8147.51n 1.8v 8197.49n 1.8v 8197.51n 1.8v 8247.49n 1.8v 8247.51n 1.8v 8297.49n 1.8v 8297.51n 0.0v 8347.49n 0.0v 8347.51n 0.0v 8397.49n 0.0v 8397.51n 0.0v 8447.49n 0.0v 8447.51n 0.0v 8497.49n 0.0v 8497.51n 0.0v 8547.49n 0.0v 8547.51n 0.0v 8597.49n 0.0v 8597.51n 0.0v 8647.49n 0.0v 8647.51n 1.8v 8697.49n 1.8v 8697.51n 0.0v 8747.49n 0.0v 8747.51n 0.0v 8797.49n 0.0v 8797.51n 1.8v 8847.49n 1.8v 8847.51n 0.0v 8897.49n 0.0v 8897.51n 1.8v 8947.49n 1.8v 8947.51n 1.8v 8997.49n 1.8v 8997.51n 0.0v 9047.49n 0.0v 9047.51n 0.0v 9097.49n 0.0v 9097.51n 0.0v 9147.49n 0.0v 9147.51n 1.8v 9197.49n 1.8v 9197.51n 0.0v 9247.49n 0.0v 9247.51n 0.0v 9297.49n 0.0v 9297.51n 1.8v 9347.49n 1.8v 9347.51n 1.8v 9397.49n 1.8v 9397.51n 1.8v 9447.49n 1.8v 9447.51n 1.8v 9497.49n 1.8v 9497.51n 1.8v 9547.49n 1.8v 9547.51n 1.8v 9597.49n 1.8v 9597.51n 1.8v 9647.49n 1.8v 9647.51n 1.8v 9697.49n 1.8v 9697.51n 1.8v 9747.49n 1.8v 9747.51n 1.8v 9797.49n 1.8v 9797.51n 1.8v 9847.49n 1.8v 9847.51n 0.0v 9897.49n 0.0v 9897.51n 0.0v 9947.49n 0.0v 9947.51n 0.0v 9997.49n 0.0v 9997.51n 1.8v 10047.49n 1.8v 10047.51n 0.0v 10097.49n 0.0v 10097.51n 1.8v 10147.49n 1.8v 10147.51n 1.8v 10197.49n 1.8v 10197.51n 1.8v 10247.49n 1.8v 10247.51n 1.8v )
* (time, data): [(0, 0), (50, 0), (100, 1), (150, 1), (200, 1), (250, 0), (300, 0), (350, 0), (400, 1), (450, 1), (500, 1), (550, 1), (600, 0), (650, 0), (700, 0), (750, 1), (800, 1), (850, 0), (900, 1), (950, 0), (1000, 0), (1050, 1), (1100, 1), (1150, 1), (1200, 1), (1250, 1), (1300, 0), (1350, 1), (1400, 1), (1450, 0), (1500, 1), (1550, 0), (1600, 1), (1650, 1), (1700, 1), (1750, 0), (1800, 0), (1850, 0), (1900, 0), (1950, 1), (2000, 1), (2050, 1), (2100, 0), (2150, 1), (2200, 0), (2250, 0), (2300, 0), (2350, 0), (2400, 0), (2450, 0), (2500, 1), (2550, 0), (2600, 1), (2650, 0), (2700, 0), (2750, 1), (2800, 1), (2850, 0), (2900, 0), (2950, 1), (3000, 1), (3050, 0), (3100, 0), (3150, 0), (3200, 0), (3250, 0), (3300, 0), (3350, 0), (3400, 0), (3450, 1), (3500, 1), (3550, 1), (3600, 1), (3650, 0), (3700, 0), (3750, 1), (3800, 1), (3850, 1), (3900, 1), (3950, 1), (4000, 1), (4050, 1), (4100, 1), (4150, 1), (4200, 1), (4250, 1), (4300, 0), (4350, 0), (4400, 1), (4450, 1), (4500, 1), (4550, 0), (4600, 0), (4650, 0), (4700, 1), (4750, 0), (4800, 0), (4850, 0), (4900, 1), (4950, 1), (5000, 0), (5050, 0), (5100, 0), (5150, 1), (5200, 1), (5250, 0), (5300, 0), (5350, 0), (5400, 0), (5450, 1), (5500, 1), (5550, 0), (5600, 0), (5650, 0), (5700, 0), (5750, 1), (5800, 1), (5850, 1), (5900, 0), (5950, 0), (6000, 1), (6050, 1), (6100, 1), (6150, 0), (6200, 1), (6250, 1), (6300, 0), (6350, 0), (6400, 0), (6450, 1), (6500, 0), (6550, 1), (6600, 1), (6650, 1), (6700, 0), (6750, 0), (6800, 0), (6850, 0), (6900, 0), (6950, 0), (7000, 1), (7050, 1), (7100, 1), (7150, 1), (7200, 0), (7250, 0), (7300, 0), (7350, 1), (7400, 0), (7450, 1), (7500, 0), (7550, 1), (7600, 0), (7650, 1), (7700, 1), (7750, 0), (7800, 0), (7850, 1), (7900, 0), (7950, 1), (8000, 0), (8050, 1), (8100, 0), (8150, 1), (8200, 1), (8250, 1), (8300, 0), (8350, 0), (8400, 0), (8450, 0), (8500, 0), (8550, 0), (8600, 0), (8650, 1), (8700, 0), (8750, 0), (8800, 1), (8850, 0), (8900, 1), (8950, 1), (9000, 0), (9050, 0), (9100, 0), (9150, 1), (9200, 0), (9250, 0), (9300, 1), (9350, 1), (9400, 1), (9450, 1), (9500, 1), (9550, 1), (9600, 1), (9650, 1), (9700, 1), (9750, 1), (9800, 1), (9850, 0), (9900, 0), (9950, 0), (10000, 1), (10050, 0), (10100, 1), (10150, 1), (10200, 1), (10250, 1)]
Va0_5  a0_5  0 PWL (0n 0.0v 47.49n 0.0v 47.51n 0.0v 97.49n 0.0v 97.51n 1.8v 147.49n 1.8v 147.51n 1.8v 197.49n 1.8v 197.51n 1.8v 247.49n 1.8v 247.51n 0.0v 297.49n 0.0v 297.51n 0.0v 347.49n 0.0v 347.51n 0.0v 397.49n 0.0v 397.51n 1.8v 447.49n 1.8v 447.51n 1.8v 497.49n 1.8v 497.51n 1.8v 547.49n 1.8v 547.51n 1.8v 597.49n 1.8v 597.51n 0.0v 647.49n 0.0v 647.51n 0.0v 697.49n 0.0v 697.51n 0.0v 747.49n 0.0v 747.51n 1.8v 797.49n 1.8v 797.51n 1.8v 847.49n 1.8v 847.51n 0.0v 897.49n 0.0v 897.51n 1.8v 947.49n 1.8v 947.51n 0.0v 997.49n 0.0v 997.51n 0.0v 1047.49n 0.0v 1047.51n 1.8v 1097.49n 1.8v 1097.51n 1.8v 1147.49n 1.8v 1147.51n 1.8v 1197.49n 1.8v 1197.51n 1.8v 1247.49n 1.8v 1247.51n 1.8v 1297.49n 1.8v 1297.51n 0.0v 1347.49n 0.0v 1347.51n 1.8v 1397.49n 1.8v 1397.51n 1.8v 1447.49n 1.8v 1447.51n 0.0v 1497.49n 0.0v 1497.51n 1.8v 1547.49n 1.8v 1547.51n 0.0v 1597.49n 0.0v 1597.51n 1.8v 1647.49n 1.8v 1647.51n 1.8v 1697.49n 1.8v 1697.51n 1.8v 1747.49n 1.8v 1747.51n 0.0v 1797.49n 0.0v 1797.51n 0.0v 1847.49n 0.0v 1847.51n 0.0v 1897.49n 0.0v 1897.51n 0.0v 1947.49n 0.0v 1947.51n 1.8v 1997.49n 1.8v 1997.51n 1.8v 2047.49n 1.8v 2047.51n 1.8v 2097.49n 1.8v 2097.51n 0.0v 2147.49n 0.0v 2147.51n 1.8v 2197.49n 1.8v 2197.51n 0.0v 2247.49n 0.0v 2247.51n 0.0v 2297.49n 0.0v 2297.51n 0.0v 2347.49n 0.0v 2347.51n 0.0v 2397.49n 0.0v 2397.51n 0.0v 2447.49n 0.0v 2447.51n 0.0v 2497.49n 0.0v 2497.51n 1.8v 2547.49n 1.8v 2547.51n 0.0v 2597.49n 0.0v 2597.51n 1.8v 2647.49n 1.8v 2647.51n 0.0v 2697.49n 0.0v 2697.51n 0.0v 2747.49n 0.0v 2747.51n 1.8v 2797.49n 1.8v 2797.51n 1.8v 2847.49n 1.8v 2847.51n 0.0v 2897.49n 0.0v 2897.51n 0.0v 2947.49n 0.0v 2947.51n 1.8v 2997.49n 1.8v 2997.51n 1.8v 3047.49n 1.8v 3047.51n 0.0v 3097.49n 0.0v 3097.51n 0.0v 3147.49n 0.0v 3147.51n 0.0v 3197.49n 0.0v 3197.51n 0.0v 3247.49n 0.0v 3247.51n 0.0v 3297.49n 0.0v 3297.51n 0.0v 3347.49n 0.0v 3347.51n 0.0v 3397.49n 0.0v 3397.51n 0.0v 3447.49n 0.0v 3447.51n 1.8v 3497.49n 1.8v 3497.51n 1.8v 3547.49n 1.8v 3547.51n 1.8v 3597.49n 1.8v 3597.51n 1.8v 3647.49n 1.8v 3647.51n 0.0v 3697.49n 0.0v 3697.51n 0.0v 3747.49n 0.0v 3747.51n 1.8v 3797.49n 1.8v 3797.51n 1.8v 3847.49n 1.8v 3847.51n 1.8v 3897.49n 1.8v 3897.51n 1.8v 3947.49n 1.8v 3947.51n 1.8v 3997.49n 1.8v 3997.51n 1.8v 4047.49n 1.8v 4047.51n 1.8v 4097.49n 1.8v 4097.51n 1.8v 4147.49n 1.8v 4147.51n 1.8v 4197.49n 1.8v 4197.51n 1.8v 4247.49n 1.8v 4247.51n 1.8v 4297.49n 1.8v 4297.51n 0.0v 4347.49n 0.0v 4347.51n 0.0v 4397.49n 0.0v 4397.51n 1.8v 4447.49n 1.8v 4447.51n 1.8v 4497.49n 1.8v 4497.51n 1.8v 4547.49n 1.8v 4547.51n 0.0v 4597.49n 0.0v 4597.51n 0.0v 4647.49n 0.0v 4647.51n 0.0v 4697.49n 0.0v 4697.51n 1.8v 4747.49n 1.8v 4747.51n 0.0v 4797.49n 0.0v 4797.51n 0.0v 4847.49n 0.0v 4847.51n 0.0v 4897.49n 0.0v 4897.51n 1.8v 4947.49n 1.8v 4947.51n 1.8v 4997.49n 1.8v 4997.51n 0.0v 5047.49n 0.0v 5047.51n 0.0v 5097.49n 0.0v 5097.51n 0.0v 5147.49n 0.0v 5147.51n 1.8v 5197.49n 1.8v 5197.51n 1.8v 5247.49n 1.8v 5247.51n 0.0v 5297.49n 0.0v 5297.51n 0.0v 5347.49n 0.0v 5347.51n 0.0v 5397.49n 0.0v 5397.51n 0.0v 5447.49n 0.0v 5447.51n 1.8v 5497.49n 1.8v 5497.51n 1.8v 5547.49n 1.8v 5547.51n 0.0v 5597.49n 0.0v 5597.51n 0.0v 5647.49n 0.0v 5647.51n 0.0v 5697.49n 0.0v 5697.51n 0.0v 5747.49n 0.0v 5747.51n 1.8v 5797.49n 1.8v 5797.51n 1.8v 5847.49n 1.8v 5847.51n 1.8v 5897.49n 1.8v 5897.51n 0.0v 5947.49n 0.0v 5947.51n 0.0v 5997.49n 0.0v 5997.51n 1.8v 6047.49n 1.8v 6047.51n 1.8v 6097.49n 1.8v 6097.51n 1.8v 6147.49n 1.8v 6147.51n 0.0v 6197.49n 0.0v 6197.51n 1.8v 6247.49n 1.8v 6247.51n 1.8v 6297.49n 1.8v 6297.51n 0.0v 6347.49n 0.0v 6347.51n 0.0v 6397.49n 0.0v 6397.51n 0.0v 6447.49n 0.0v 6447.51n 1.8v 6497.49n 1.8v 6497.51n 0.0v 6547.49n 0.0v 6547.51n 1.8v 6597.49n 1.8v 6597.51n 1.8v 6647.49n 1.8v 6647.51n 1.8v 6697.49n 1.8v 6697.51n 0.0v 6747.49n 0.0v 6747.51n 0.0v 6797.49n 0.0v 6797.51n 0.0v 6847.49n 0.0v 6847.51n 0.0v 6897.49n 0.0v 6897.51n 0.0v 6947.49n 0.0v 6947.51n 0.0v 6997.49n 0.0v 6997.51n 1.8v 7047.49n 1.8v 7047.51n 1.8v 7097.49n 1.8v 7097.51n 1.8v 7147.49n 1.8v 7147.51n 1.8v 7197.49n 1.8v 7197.51n 0.0v 7247.49n 0.0v 7247.51n 0.0v 7297.49n 0.0v 7297.51n 0.0v 7347.49n 0.0v 7347.51n 1.8v 7397.49n 1.8v 7397.51n 0.0v 7447.49n 0.0v 7447.51n 1.8v 7497.49n 1.8v 7497.51n 0.0v 7547.49n 0.0v 7547.51n 1.8v 7597.49n 1.8v 7597.51n 0.0v 7647.49n 0.0v 7647.51n 1.8v 7697.49n 1.8v 7697.51n 1.8v 7747.49n 1.8v 7747.51n 0.0v 7797.49n 0.0v 7797.51n 0.0v 7847.49n 0.0v 7847.51n 1.8v 7897.49n 1.8v 7897.51n 0.0v 7947.49n 0.0v 7947.51n 1.8v 7997.49n 1.8v 7997.51n 0.0v 8047.49n 0.0v 8047.51n 1.8v 8097.49n 1.8v 8097.51n 0.0v 8147.49n 0.0v 8147.51n 1.8v 8197.49n 1.8v 8197.51n 1.8v 8247.49n 1.8v 8247.51n 1.8v 8297.49n 1.8v 8297.51n 0.0v 8347.49n 0.0v 8347.51n 0.0v 8397.49n 0.0v 8397.51n 0.0v 8447.49n 0.0v 8447.51n 0.0v 8497.49n 0.0v 8497.51n 0.0v 8547.49n 0.0v 8547.51n 0.0v 8597.49n 0.0v 8597.51n 0.0v 8647.49n 0.0v 8647.51n 1.8v 8697.49n 1.8v 8697.51n 0.0v 8747.49n 0.0v 8747.51n 0.0v 8797.49n 0.0v 8797.51n 1.8v 8847.49n 1.8v 8847.51n 0.0v 8897.49n 0.0v 8897.51n 1.8v 8947.49n 1.8v 8947.51n 1.8v 8997.49n 1.8v 8997.51n 0.0v 9047.49n 0.0v 9047.51n 0.0v 9097.49n 0.0v 9097.51n 0.0v 9147.49n 0.0v 9147.51n 1.8v 9197.49n 1.8v 9197.51n 0.0v 9247.49n 0.0v 9247.51n 0.0v 9297.49n 0.0v 9297.51n 1.8v 9347.49n 1.8v 9347.51n 1.8v 9397.49n 1.8v 9397.51n 1.8v 9447.49n 1.8v 9447.51n 1.8v 9497.49n 1.8v 9497.51n 1.8v 9547.49n 1.8v 9547.51n 1.8v 9597.49n 1.8v 9597.51n 1.8v 9647.49n 1.8v 9647.51n 1.8v 9697.49n 1.8v 9697.51n 1.8v 9747.49n 1.8v 9747.51n 1.8v 9797.49n 1.8v 9797.51n 1.8v 9847.49n 1.8v 9847.51n 0.0v 9897.49n 0.0v 9897.51n 0.0v 9947.49n 0.0v 9947.51n 0.0v 9997.49n 0.0v 9997.51n 1.8v 10047.49n 1.8v 10047.51n 0.0v 10097.49n 0.0v 10097.51n 1.8v 10147.49n 1.8v 10147.51n 1.8v 10197.49n 1.8v 10197.51n 1.8v 10247.49n 1.8v 10247.51n 1.8v )
* (time, data): [(0, 0), (50, 0), (100, 1), (150, 1), (200, 1), (250, 0), (300, 0), (350, 0), (400, 1), (450, 1), (500, 1), (550, 1), (600, 0), (650, 0), (700, 0), (750, 1), (800, 1), (850, 0), (900, 1), (950, 0), (1000, 0), (1050, 1), (1100, 1), (1150, 1), (1200, 1), (1250, 1), (1300, 0), (1350, 1), (1400, 1), (1450, 0), (1500, 1), (1550, 0), (1600, 1), (1650, 1), (1700, 1), (1750, 0), (1800, 0), (1850, 0), (1900, 0), (1950, 1), (2000, 1), (2050, 1), (2100, 0), (2150, 1), (2200, 0), (2250, 0), (2300, 0), (2350, 0), (2400, 0), (2450, 0), (2500, 1), (2550, 0), (2600, 1), (2650, 0), (2700, 0), (2750, 1), (2800, 1), (2850, 0), (2900, 0), (2950, 1), (3000, 1), (3050, 0), (3100, 0), (3150, 0), (3200, 0), (3250, 0), (3300, 0), (3350, 0), (3400, 0), (3450, 1), (3500, 1), (3550, 1), (3600, 1), (3650, 0), (3700, 0), (3750, 1), (3800, 1), (3850, 1), (3900, 1), (3950, 1), (4000, 1), (4050, 1), (4100, 1), (4150, 1), (4200, 1), (4250, 1), (4300, 0), (4350, 0), (4400, 1), (4450, 1), (4500, 1), (4550, 0), (4600, 0), (4650, 0), (4700, 1), (4750, 0), (4800, 0), (4850, 0), (4900, 1), (4950, 1), (5000, 0), (5050, 0), (5100, 0), (5150, 1), (5200, 1), (5250, 0), (5300, 0), (5350, 0), (5400, 0), (5450, 1), (5500, 1), (5550, 0), (5600, 0), (5650, 0), (5700, 0), (5750, 1), (5800, 1), (5850, 1), (5900, 0), (5950, 0), (6000, 1), (6050, 1), (6100, 1), (6150, 0), (6200, 1), (6250, 1), (6300, 0), (6350, 0), (6400, 0), (6450, 1), (6500, 0), (6550, 1), (6600, 1), (6650, 1), (6700, 0), (6750, 0), (6800, 0), (6850, 0), (6900, 0), (6950, 0), (7000, 1), (7050, 1), (7100, 1), (7150, 1), (7200, 0), (7250, 0), (7300, 0), (7350, 1), (7400, 0), (7450, 1), (7500, 0), (7550, 1), (7600, 0), (7650, 1), (7700, 1), (7750, 0), (7800, 0), (7850, 1), (7900, 0), (7950, 1), (8000, 0), (8050, 1), (8100, 0), (8150, 1), (8200, 1), (8250, 1), (8300, 0), (8350, 0), (8400, 0), (8450, 0), (8500, 0), (8550, 0), (8600, 0), (8650, 1), (8700, 0), (8750, 0), (8800, 1), (8850, 0), (8900, 1), (8950, 1), (9000, 0), (9050, 0), (9100, 0), (9150, 1), (9200, 0), (9250, 0), (9300, 1), (9350, 1), (9400, 1), (9450, 1), (9500, 1), (9550, 1), (9600, 1), (9650, 1), (9700, 1), (9750, 1), (9800, 1), (9850, 0), (9900, 0), (9950, 0), (10000, 1), (10050, 0), (10100, 1), (10150, 1), (10200, 1), (10250, 1)]
Va0_6  a0_6  0 PWL (0n 0.0v 47.49n 0.0v 47.51n 0.0v 97.49n 0.0v 97.51n 1.8v 147.49n 1.8v 147.51n 1.8v 197.49n 1.8v 197.51n 1.8v 247.49n 1.8v 247.51n 0.0v 297.49n 0.0v 297.51n 0.0v 347.49n 0.0v 347.51n 0.0v 397.49n 0.0v 397.51n 1.8v 447.49n 1.8v 447.51n 1.8v 497.49n 1.8v 497.51n 1.8v 547.49n 1.8v 547.51n 1.8v 597.49n 1.8v 597.51n 0.0v 647.49n 0.0v 647.51n 0.0v 697.49n 0.0v 697.51n 0.0v 747.49n 0.0v 747.51n 1.8v 797.49n 1.8v 797.51n 1.8v 847.49n 1.8v 847.51n 0.0v 897.49n 0.0v 897.51n 1.8v 947.49n 1.8v 947.51n 0.0v 997.49n 0.0v 997.51n 0.0v 1047.49n 0.0v 1047.51n 1.8v 1097.49n 1.8v 1097.51n 1.8v 1147.49n 1.8v 1147.51n 1.8v 1197.49n 1.8v 1197.51n 1.8v 1247.49n 1.8v 1247.51n 1.8v 1297.49n 1.8v 1297.51n 0.0v 1347.49n 0.0v 1347.51n 1.8v 1397.49n 1.8v 1397.51n 1.8v 1447.49n 1.8v 1447.51n 0.0v 1497.49n 0.0v 1497.51n 1.8v 1547.49n 1.8v 1547.51n 0.0v 1597.49n 0.0v 1597.51n 1.8v 1647.49n 1.8v 1647.51n 1.8v 1697.49n 1.8v 1697.51n 1.8v 1747.49n 1.8v 1747.51n 0.0v 1797.49n 0.0v 1797.51n 0.0v 1847.49n 0.0v 1847.51n 0.0v 1897.49n 0.0v 1897.51n 0.0v 1947.49n 0.0v 1947.51n 1.8v 1997.49n 1.8v 1997.51n 1.8v 2047.49n 1.8v 2047.51n 1.8v 2097.49n 1.8v 2097.51n 0.0v 2147.49n 0.0v 2147.51n 1.8v 2197.49n 1.8v 2197.51n 0.0v 2247.49n 0.0v 2247.51n 0.0v 2297.49n 0.0v 2297.51n 0.0v 2347.49n 0.0v 2347.51n 0.0v 2397.49n 0.0v 2397.51n 0.0v 2447.49n 0.0v 2447.51n 0.0v 2497.49n 0.0v 2497.51n 1.8v 2547.49n 1.8v 2547.51n 0.0v 2597.49n 0.0v 2597.51n 1.8v 2647.49n 1.8v 2647.51n 0.0v 2697.49n 0.0v 2697.51n 0.0v 2747.49n 0.0v 2747.51n 1.8v 2797.49n 1.8v 2797.51n 1.8v 2847.49n 1.8v 2847.51n 0.0v 2897.49n 0.0v 2897.51n 0.0v 2947.49n 0.0v 2947.51n 1.8v 2997.49n 1.8v 2997.51n 1.8v 3047.49n 1.8v 3047.51n 0.0v 3097.49n 0.0v 3097.51n 0.0v 3147.49n 0.0v 3147.51n 0.0v 3197.49n 0.0v 3197.51n 0.0v 3247.49n 0.0v 3247.51n 0.0v 3297.49n 0.0v 3297.51n 0.0v 3347.49n 0.0v 3347.51n 0.0v 3397.49n 0.0v 3397.51n 0.0v 3447.49n 0.0v 3447.51n 1.8v 3497.49n 1.8v 3497.51n 1.8v 3547.49n 1.8v 3547.51n 1.8v 3597.49n 1.8v 3597.51n 1.8v 3647.49n 1.8v 3647.51n 0.0v 3697.49n 0.0v 3697.51n 0.0v 3747.49n 0.0v 3747.51n 1.8v 3797.49n 1.8v 3797.51n 1.8v 3847.49n 1.8v 3847.51n 1.8v 3897.49n 1.8v 3897.51n 1.8v 3947.49n 1.8v 3947.51n 1.8v 3997.49n 1.8v 3997.51n 1.8v 4047.49n 1.8v 4047.51n 1.8v 4097.49n 1.8v 4097.51n 1.8v 4147.49n 1.8v 4147.51n 1.8v 4197.49n 1.8v 4197.51n 1.8v 4247.49n 1.8v 4247.51n 1.8v 4297.49n 1.8v 4297.51n 0.0v 4347.49n 0.0v 4347.51n 0.0v 4397.49n 0.0v 4397.51n 1.8v 4447.49n 1.8v 4447.51n 1.8v 4497.49n 1.8v 4497.51n 1.8v 4547.49n 1.8v 4547.51n 0.0v 4597.49n 0.0v 4597.51n 0.0v 4647.49n 0.0v 4647.51n 0.0v 4697.49n 0.0v 4697.51n 1.8v 4747.49n 1.8v 4747.51n 0.0v 4797.49n 0.0v 4797.51n 0.0v 4847.49n 0.0v 4847.51n 0.0v 4897.49n 0.0v 4897.51n 1.8v 4947.49n 1.8v 4947.51n 1.8v 4997.49n 1.8v 4997.51n 0.0v 5047.49n 0.0v 5047.51n 0.0v 5097.49n 0.0v 5097.51n 0.0v 5147.49n 0.0v 5147.51n 1.8v 5197.49n 1.8v 5197.51n 1.8v 5247.49n 1.8v 5247.51n 0.0v 5297.49n 0.0v 5297.51n 0.0v 5347.49n 0.0v 5347.51n 0.0v 5397.49n 0.0v 5397.51n 0.0v 5447.49n 0.0v 5447.51n 1.8v 5497.49n 1.8v 5497.51n 1.8v 5547.49n 1.8v 5547.51n 0.0v 5597.49n 0.0v 5597.51n 0.0v 5647.49n 0.0v 5647.51n 0.0v 5697.49n 0.0v 5697.51n 0.0v 5747.49n 0.0v 5747.51n 1.8v 5797.49n 1.8v 5797.51n 1.8v 5847.49n 1.8v 5847.51n 1.8v 5897.49n 1.8v 5897.51n 0.0v 5947.49n 0.0v 5947.51n 0.0v 5997.49n 0.0v 5997.51n 1.8v 6047.49n 1.8v 6047.51n 1.8v 6097.49n 1.8v 6097.51n 1.8v 6147.49n 1.8v 6147.51n 0.0v 6197.49n 0.0v 6197.51n 1.8v 6247.49n 1.8v 6247.51n 1.8v 6297.49n 1.8v 6297.51n 0.0v 6347.49n 0.0v 6347.51n 0.0v 6397.49n 0.0v 6397.51n 0.0v 6447.49n 0.0v 6447.51n 1.8v 6497.49n 1.8v 6497.51n 0.0v 6547.49n 0.0v 6547.51n 1.8v 6597.49n 1.8v 6597.51n 1.8v 6647.49n 1.8v 6647.51n 1.8v 6697.49n 1.8v 6697.51n 0.0v 6747.49n 0.0v 6747.51n 0.0v 6797.49n 0.0v 6797.51n 0.0v 6847.49n 0.0v 6847.51n 0.0v 6897.49n 0.0v 6897.51n 0.0v 6947.49n 0.0v 6947.51n 0.0v 6997.49n 0.0v 6997.51n 1.8v 7047.49n 1.8v 7047.51n 1.8v 7097.49n 1.8v 7097.51n 1.8v 7147.49n 1.8v 7147.51n 1.8v 7197.49n 1.8v 7197.51n 0.0v 7247.49n 0.0v 7247.51n 0.0v 7297.49n 0.0v 7297.51n 0.0v 7347.49n 0.0v 7347.51n 1.8v 7397.49n 1.8v 7397.51n 0.0v 7447.49n 0.0v 7447.51n 1.8v 7497.49n 1.8v 7497.51n 0.0v 7547.49n 0.0v 7547.51n 1.8v 7597.49n 1.8v 7597.51n 0.0v 7647.49n 0.0v 7647.51n 1.8v 7697.49n 1.8v 7697.51n 1.8v 7747.49n 1.8v 7747.51n 0.0v 7797.49n 0.0v 7797.51n 0.0v 7847.49n 0.0v 7847.51n 1.8v 7897.49n 1.8v 7897.51n 0.0v 7947.49n 0.0v 7947.51n 1.8v 7997.49n 1.8v 7997.51n 0.0v 8047.49n 0.0v 8047.51n 1.8v 8097.49n 1.8v 8097.51n 0.0v 8147.49n 0.0v 8147.51n 1.8v 8197.49n 1.8v 8197.51n 1.8v 8247.49n 1.8v 8247.51n 1.8v 8297.49n 1.8v 8297.51n 0.0v 8347.49n 0.0v 8347.51n 0.0v 8397.49n 0.0v 8397.51n 0.0v 8447.49n 0.0v 8447.51n 0.0v 8497.49n 0.0v 8497.51n 0.0v 8547.49n 0.0v 8547.51n 0.0v 8597.49n 0.0v 8597.51n 0.0v 8647.49n 0.0v 8647.51n 1.8v 8697.49n 1.8v 8697.51n 0.0v 8747.49n 0.0v 8747.51n 0.0v 8797.49n 0.0v 8797.51n 1.8v 8847.49n 1.8v 8847.51n 0.0v 8897.49n 0.0v 8897.51n 1.8v 8947.49n 1.8v 8947.51n 1.8v 8997.49n 1.8v 8997.51n 0.0v 9047.49n 0.0v 9047.51n 0.0v 9097.49n 0.0v 9097.51n 0.0v 9147.49n 0.0v 9147.51n 1.8v 9197.49n 1.8v 9197.51n 0.0v 9247.49n 0.0v 9247.51n 0.0v 9297.49n 0.0v 9297.51n 1.8v 9347.49n 1.8v 9347.51n 1.8v 9397.49n 1.8v 9397.51n 1.8v 9447.49n 1.8v 9447.51n 1.8v 9497.49n 1.8v 9497.51n 1.8v 9547.49n 1.8v 9547.51n 1.8v 9597.49n 1.8v 9597.51n 1.8v 9647.49n 1.8v 9647.51n 1.8v 9697.49n 1.8v 9697.51n 1.8v 9747.49n 1.8v 9747.51n 1.8v 9797.49n 1.8v 9797.51n 1.8v 9847.49n 1.8v 9847.51n 0.0v 9897.49n 0.0v 9897.51n 0.0v 9947.49n 0.0v 9947.51n 0.0v 9997.49n 0.0v 9997.51n 1.8v 10047.49n 1.8v 10047.51n 0.0v 10097.49n 0.0v 10097.51n 1.8v 10147.49n 1.8v 10147.51n 1.8v 10197.49n 1.8v 10197.51n 1.8v 10247.49n 1.8v 10247.51n 1.8v )
* (time, data): [(0, 0), (50, 0), (100, 1), (150, 1), (200, 1), (250, 0), (300, 0), (350, 0), (400, 1), (450, 1), (500, 1), (550, 1), (600, 0), (650, 0), (700, 0), (750, 1), (800, 1), (850, 0), (900, 1), (950, 0), (1000, 0), (1050, 1), (1100, 1), (1150, 1), (1200, 1), (1250, 1), (1300, 0), (1350, 1), (1400, 1), (1450, 0), (1500, 1), (1550, 0), (1600, 1), (1650, 1), (1700, 1), (1750, 0), (1800, 0), (1850, 0), (1900, 0), (1950, 1), (2000, 1), (2050, 1), (2100, 0), (2150, 1), (2200, 0), (2250, 0), (2300, 0), (2350, 0), (2400, 0), (2450, 0), (2500, 1), (2550, 0), (2600, 1), (2650, 0), (2700, 0), (2750, 1), (2800, 1), (2850, 0), (2900, 0), (2950, 1), (3000, 1), (3050, 0), (3100, 0), (3150, 0), (3200, 0), (3250, 0), (3300, 0), (3350, 0), (3400, 0), (3450, 1), (3500, 1), (3550, 1), (3600, 1), (3650, 0), (3700, 0), (3750, 1), (3800, 1), (3850, 1), (3900, 1), (3950, 1), (4000, 1), (4050, 1), (4100, 1), (4150, 1), (4200, 1), (4250, 1), (4300, 0), (4350, 0), (4400, 1), (4450, 1), (4500, 1), (4550, 0), (4600, 0), (4650, 0), (4700, 1), (4750, 0), (4800, 0), (4850, 0), (4900, 1), (4950, 1), (5000, 0), (5050, 0), (5100, 0), (5150, 1), (5200, 1), (5250, 0), (5300, 0), (5350, 0), (5400, 0), (5450, 1), (5500, 1), (5550, 0), (5600, 0), (5650, 0), (5700, 0), (5750, 1), (5800, 1), (5850, 1), (5900, 0), (5950, 0), (6000, 1), (6050, 1), (6100, 1), (6150, 0), (6200, 1), (6250, 1), (6300, 0), (6350, 0), (6400, 0), (6450, 1), (6500, 0), (6550, 1), (6600, 1), (6650, 1), (6700, 0), (6750, 0), (6800, 0), (6850, 0), (6900, 0), (6950, 0), (7000, 1), (7050, 1), (7100, 1), (7150, 1), (7200, 0), (7250, 0), (7300, 0), (7350, 1), (7400, 0), (7450, 1), (7500, 0), (7550, 1), (7600, 0), (7650, 1), (7700, 1), (7750, 0), (7800, 0), (7850, 1), (7900, 0), (7950, 1), (8000, 0), (8050, 1), (8100, 0), (8150, 1), (8200, 1), (8250, 1), (8300, 0), (8350, 0), (8400, 0), (8450, 0), (8500, 0), (8550, 0), (8600, 0), (8650, 1), (8700, 0), (8750, 0), (8800, 1), (8850, 0), (8900, 1), (8950, 1), (9000, 0), (9050, 0), (9100, 0), (9150, 1), (9200, 0), (9250, 0), (9300, 1), (9350, 1), (9400, 1), (9450, 1), (9500, 1), (9550, 1), (9600, 1), (9650, 1), (9700, 1), (9750, 1), (9800, 1), (9850, 0), (9900, 0), (9950, 0), (10000, 1), (10050, 0), (10100, 1), (10150, 1), (10200, 1), (10250, 1)]
Va0_7  a0_7  0 PWL (0n 0.0v 47.49n 0.0v 47.51n 0.0v 97.49n 0.0v 97.51n 1.8v 147.49n 1.8v 147.51n 1.8v 197.49n 1.8v 197.51n 1.8v 247.49n 1.8v 247.51n 0.0v 297.49n 0.0v 297.51n 0.0v 347.49n 0.0v 347.51n 0.0v 397.49n 0.0v 397.51n 1.8v 447.49n 1.8v 447.51n 1.8v 497.49n 1.8v 497.51n 1.8v 547.49n 1.8v 547.51n 1.8v 597.49n 1.8v 597.51n 0.0v 647.49n 0.0v 647.51n 0.0v 697.49n 0.0v 697.51n 0.0v 747.49n 0.0v 747.51n 1.8v 797.49n 1.8v 797.51n 1.8v 847.49n 1.8v 847.51n 0.0v 897.49n 0.0v 897.51n 1.8v 947.49n 1.8v 947.51n 0.0v 997.49n 0.0v 997.51n 0.0v 1047.49n 0.0v 1047.51n 1.8v 1097.49n 1.8v 1097.51n 1.8v 1147.49n 1.8v 1147.51n 1.8v 1197.49n 1.8v 1197.51n 1.8v 1247.49n 1.8v 1247.51n 1.8v 1297.49n 1.8v 1297.51n 0.0v 1347.49n 0.0v 1347.51n 1.8v 1397.49n 1.8v 1397.51n 1.8v 1447.49n 1.8v 1447.51n 0.0v 1497.49n 0.0v 1497.51n 1.8v 1547.49n 1.8v 1547.51n 0.0v 1597.49n 0.0v 1597.51n 1.8v 1647.49n 1.8v 1647.51n 1.8v 1697.49n 1.8v 1697.51n 1.8v 1747.49n 1.8v 1747.51n 0.0v 1797.49n 0.0v 1797.51n 0.0v 1847.49n 0.0v 1847.51n 0.0v 1897.49n 0.0v 1897.51n 0.0v 1947.49n 0.0v 1947.51n 1.8v 1997.49n 1.8v 1997.51n 1.8v 2047.49n 1.8v 2047.51n 1.8v 2097.49n 1.8v 2097.51n 0.0v 2147.49n 0.0v 2147.51n 1.8v 2197.49n 1.8v 2197.51n 0.0v 2247.49n 0.0v 2247.51n 0.0v 2297.49n 0.0v 2297.51n 0.0v 2347.49n 0.0v 2347.51n 0.0v 2397.49n 0.0v 2397.51n 0.0v 2447.49n 0.0v 2447.51n 0.0v 2497.49n 0.0v 2497.51n 1.8v 2547.49n 1.8v 2547.51n 0.0v 2597.49n 0.0v 2597.51n 1.8v 2647.49n 1.8v 2647.51n 0.0v 2697.49n 0.0v 2697.51n 0.0v 2747.49n 0.0v 2747.51n 1.8v 2797.49n 1.8v 2797.51n 1.8v 2847.49n 1.8v 2847.51n 0.0v 2897.49n 0.0v 2897.51n 0.0v 2947.49n 0.0v 2947.51n 1.8v 2997.49n 1.8v 2997.51n 1.8v 3047.49n 1.8v 3047.51n 0.0v 3097.49n 0.0v 3097.51n 0.0v 3147.49n 0.0v 3147.51n 0.0v 3197.49n 0.0v 3197.51n 0.0v 3247.49n 0.0v 3247.51n 0.0v 3297.49n 0.0v 3297.51n 0.0v 3347.49n 0.0v 3347.51n 0.0v 3397.49n 0.0v 3397.51n 0.0v 3447.49n 0.0v 3447.51n 1.8v 3497.49n 1.8v 3497.51n 1.8v 3547.49n 1.8v 3547.51n 1.8v 3597.49n 1.8v 3597.51n 1.8v 3647.49n 1.8v 3647.51n 0.0v 3697.49n 0.0v 3697.51n 0.0v 3747.49n 0.0v 3747.51n 1.8v 3797.49n 1.8v 3797.51n 1.8v 3847.49n 1.8v 3847.51n 1.8v 3897.49n 1.8v 3897.51n 1.8v 3947.49n 1.8v 3947.51n 1.8v 3997.49n 1.8v 3997.51n 1.8v 4047.49n 1.8v 4047.51n 1.8v 4097.49n 1.8v 4097.51n 1.8v 4147.49n 1.8v 4147.51n 1.8v 4197.49n 1.8v 4197.51n 1.8v 4247.49n 1.8v 4247.51n 1.8v 4297.49n 1.8v 4297.51n 0.0v 4347.49n 0.0v 4347.51n 0.0v 4397.49n 0.0v 4397.51n 1.8v 4447.49n 1.8v 4447.51n 1.8v 4497.49n 1.8v 4497.51n 1.8v 4547.49n 1.8v 4547.51n 0.0v 4597.49n 0.0v 4597.51n 0.0v 4647.49n 0.0v 4647.51n 0.0v 4697.49n 0.0v 4697.51n 1.8v 4747.49n 1.8v 4747.51n 0.0v 4797.49n 0.0v 4797.51n 0.0v 4847.49n 0.0v 4847.51n 0.0v 4897.49n 0.0v 4897.51n 1.8v 4947.49n 1.8v 4947.51n 1.8v 4997.49n 1.8v 4997.51n 0.0v 5047.49n 0.0v 5047.51n 0.0v 5097.49n 0.0v 5097.51n 0.0v 5147.49n 0.0v 5147.51n 1.8v 5197.49n 1.8v 5197.51n 1.8v 5247.49n 1.8v 5247.51n 0.0v 5297.49n 0.0v 5297.51n 0.0v 5347.49n 0.0v 5347.51n 0.0v 5397.49n 0.0v 5397.51n 0.0v 5447.49n 0.0v 5447.51n 1.8v 5497.49n 1.8v 5497.51n 1.8v 5547.49n 1.8v 5547.51n 0.0v 5597.49n 0.0v 5597.51n 0.0v 5647.49n 0.0v 5647.51n 0.0v 5697.49n 0.0v 5697.51n 0.0v 5747.49n 0.0v 5747.51n 1.8v 5797.49n 1.8v 5797.51n 1.8v 5847.49n 1.8v 5847.51n 1.8v 5897.49n 1.8v 5897.51n 0.0v 5947.49n 0.0v 5947.51n 0.0v 5997.49n 0.0v 5997.51n 1.8v 6047.49n 1.8v 6047.51n 1.8v 6097.49n 1.8v 6097.51n 1.8v 6147.49n 1.8v 6147.51n 0.0v 6197.49n 0.0v 6197.51n 1.8v 6247.49n 1.8v 6247.51n 1.8v 6297.49n 1.8v 6297.51n 0.0v 6347.49n 0.0v 6347.51n 0.0v 6397.49n 0.0v 6397.51n 0.0v 6447.49n 0.0v 6447.51n 1.8v 6497.49n 1.8v 6497.51n 0.0v 6547.49n 0.0v 6547.51n 1.8v 6597.49n 1.8v 6597.51n 1.8v 6647.49n 1.8v 6647.51n 1.8v 6697.49n 1.8v 6697.51n 0.0v 6747.49n 0.0v 6747.51n 0.0v 6797.49n 0.0v 6797.51n 0.0v 6847.49n 0.0v 6847.51n 0.0v 6897.49n 0.0v 6897.51n 0.0v 6947.49n 0.0v 6947.51n 0.0v 6997.49n 0.0v 6997.51n 1.8v 7047.49n 1.8v 7047.51n 1.8v 7097.49n 1.8v 7097.51n 1.8v 7147.49n 1.8v 7147.51n 1.8v 7197.49n 1.8v 7197.51n 0.0v 7247.49n 0.0v 7247.51n 0.0v 7297.49n 0.0v 7297.51n 0.0v 7347.49n 0.0v 7347.51n 1.8v 7397.49n 1.8v 7397.51n 0.0v 7447.49n 0.0v 7447.51n 1.8v 7497.49n 1.8v 7497.51n 0.0v 7547.49n 0.0v 7547.51n 1.8v 7597.49n 1.8v 7597.51n 0.0v 7647.49n 0.0v 7647.51n 1.8v 7697.49n 1.8v 7697.51n 1.8v 7747.49n 1.8v 7747.51n 0.0v 7797.49n 0.0v 7797.51n 0.0v 7847.49n 0.0v 7847.51n 1.8v 7897.49n 1.8v 7897.51n 0.0v 7947.49n 0.0v 7947.51n 1.8v 7997.49n 1.8v 7997.51n 0.0v 8047.49n 0.0v 8047.51n 1.8v 8097.49n 1.8v 8097.51n 0.0v 8147.49n 0.0v 8147.51n 1.8v 8197.49n 1.8v 8197.51n 1.8v 8247.49n 1.8v 8247.51n 1.8v 8297.49n 1.8v 8297.51n 0.0v 8347.49n 0.0v 8347.51n 0.0v 8397.49n 0.0v 8397.51n 0.0v 8447.49n 0.0v 8447.51n 0.0v 8497.49n 0.0v 8497.51n 0.0v 8547.49n 0.0v 8547.51n 0.0v 8597.49n 0.0v 8597.51n 0.0v 8647.49n 0.0v 8647.51n 1.8v 8697.49n 1.8v 8697.51n 0.0v 8747.49n 0.0v 8747.51n 0.0v 8797.49n 0.0v 8797.51n 1.8v 8847.49n 1.8v 8847.51n 0.0v 8897.49n 0.0v 8897.51n 1.8v 8947.49n 1.8v 8947.51n 1.8v 8997.49n 1.8v 8997.51n 0.0v 9047.49n 0.0v 9047.51n 0.0v 9097.49n 0.0v 9097.51n 0.0v 9147.49n 0.0v 9147.51n 1.8v 9197.49n 1.8v 9197.51n 0.0v 9247.49n 0.0v 9247.51n 0.0v 9297.49n 0.0v 9297.51n 1.8v 9347.49n 1.8v 9347.51n 1.8v 9397.49n 1.8v 9397.51n 1.8v 9447.49n 1.8v 9447.51n 1.8v 9497.49n 1.8v 9497.51n 1.8v 9547.49n 1.8v 9547.51n 1.8v 9597.49n 1.8v 9597.51n 1.8v 9647.49n 1.8v 9647.51n 1.8v 9697.49n 1.8v 9697.51n 1.8v 9747.49n 1.8v 9747.51n 1.8v 9797.49n 1.8v 9797.51n 1.8v 9847.49n 1.8v 9847.51n 0.0v 9897.49n 0.0v 9897.51n 0.0v 9947.49n 0.0v 9947.51n 0.0v 9997.49n 0.0v 9997.51n 1.8v 10047.49n 1.8v 10047.51n 0.0v 10097.49n 0.0v 10097.51n 1.8v 10147.49n 1.8v 10147.51n 1.8v 10197.49n 1.8v 10197.51n 1.8v 10247.49n 1.8v 10247.51n 1.8v )
* (time, data): [(0, 0), (50, 0), (100, 1), (150, 1), (200, 1), (250, 0), (300, 0), (350, 0), (400, 1), (450, 1), (500, 1), (550, 1), (600, 0), (650, 0), (700, 0), (750, 1), (800, 1), (850, 0), (900, 1), (950, 0), (1000, 0), (1050, 1), (1100, 1), (1150, 1), (1200, 1), (1250, 1), (1300, 0), (1350, 1), (1400, 1), (1450, 0), (1500, 1), (1550, 0), (1600, 1), (1650, 1), (1700, 1), (1750, 0), (1800, 0), (1850, 0), (1900, 0), (1950, 1), (2000, 1), (2050, 1), (2100, 0), (2150, 1), (2200, 0), (2250, 0), (2300, 0), (2350, 0), (2400, 0), (2450, 0), (2500, 1), (2550, 0), (2600, 1), (2650, 0), (2700, 0), (2750, 1), (2800, 1), (2850, 0), (2900, 0), (2950, 1), (3000, 1), (3050, 0), (3100, 0), (3150, 0), (3200, 0), (3250, 0), (3300, 0), (3350, 0), (3400, 0), (3450, 1), (3500, 1), (3550, 1), (3600, 1), (3650, 0), (3700, 0), (3750, 1), (3800, 1), (3850, 1), (3900, 1), (3950, 1), (4000, 1), (4050, 1), (4100, 1), (4150, 1), (4200, 1), (4250, 1), (4300, 0), (4350, 0), (4400, 1), (4450, 1), (4500, 1), (4550, 0), (4600, 0), (4650, 0), (4700, 1), (4750, 0), (4800, 0), (4850, 0), (4900, 1), (4950, 1), (5000, 0), (5050, 0), (5100, 0), (5150, 1), (5200, 1), (5250, 0), (5300, 0), (5350, 0), (5400, 0), (5450, 1), (5500, 1), (5550, 0), (5600, 0), (5650, 0), (5700, 0), (5750, 1), (5800, 1), (5850, 1), (5900, 0), (5950, 0), (6000, 1), (6050, 1), (6100, 1), (6150, 0), (6200, 1), (6250, 1), (6300, 0), (6350, 0), (6400, 0), (6450, 1), (6500, 0), (6550, 1), (6600, 1), (6650, 1), (6700, 0), (6750, 0), (6800, 0), (6850, 0), (6900, 0), (6950, 0), (7000, 1), (7050, 1), (7100, 1), (7150, 1), (7200, 0), (7250, 0), (7300, 0), (7350, 1), (7400, 0), (7450, 1), (7500, 0), (7550, 1), (7600, 0), (7650, 1), (7700, 1), (7750, 0), (7800, 0), (7850, 1), (7900, 0), (7950, 1), (8000, 0), (8050, 1), (8100, 0), (8150, 1), (8200, 1), (8250, 1), (8300, 0), (8350, 0), (8400, 0), (8450, 0), (8500, 0), (8550, 0), (8600, 0), (8650, 1), (8700, 0), (8750, 0), (8800, 1), (8850, 0), (8900, 1), (8950, 1), (9000, 0), (9050, 0), (9100, 0), (9150, 1), (9200, 0), (9250, 0), (9300, 1), (9350, 1), (9400, 1), (9450, 1), (9500, 1), (9550, 1), (9600, 1), (9650, 1), (9700, 1), (9750, 1), (9800, 1), (9850, 0), (9900, 0), (9950, 0), (10000, 1), (10050, 0), (10100, 1), (10150, 1), (10200, 1), (10250, 1)]
Va0_8  a0_8  0 PWL (0n 0.0v 47.49n 0.0v 47.51n 0.0v 97.49n 0.0v 97.51n 1.8v 147.49n 1.8v 147.51n 1.8v 197.49n 1.8v 197.51n 1.8v 247.49n 1.8v 247.51n 0.0v 297.49n 0.0v 297.51n 0.0v 347.49n 0.0v 347.51n 0.0v 397.49n 0.0v 397.51n 1.8v 447.49n 1.8v 447.51n 1.8v 497.49n 1.8v 497.51n 1.8v 547.49n 1.8v 547.51n 1.8v 597.49n 1.8v 597.51n 0.0v 647.49n 0.0v 647.51n 0.0v 697.49n 0.0v 697.51n 0.0v 747.49n 0.0v 747.51n 1.8v 797.49n 1.8v 797.51n 1.8v 847.49n 1.8v 847.51n 0.0v 897.49n 0.0v 897.51n 1.8v 947.49n 1.8v 947.51n 0.0v 997.49n 0.0v 997.51n 0.0v 1047.49n 0.0v 1047.51n 1.8v 1097.49n 1.8v 1097.51n 1.8v 1147.49n 1.8v 1147.51n 1.8v 1197.49n 1.8v 1197.51n 1.8v 1247.49n 1.8v 1247.51n 1.8v 1297.49n 1.8v 1297.51n 0.0v 1347.49n 0.0v 1347.51n 1.8v 1397.49n 1.8v 1397.51n 1.8v 1447.49n 1.8v 1447.51n 0.0v 1497.49n 0.0v 1497.51n 1.8v 1547.49n 1.8v 1547.51n 0.0v 1597.49n 0.0v 1597.51n 1.8v 1647.49n 1.8v 1647.51n 1.8v 1697.49n 1.8v 1697.51n 1.8v 1747.49n 1.8v 1747.51n 0.0v 1797.49n 0.0v 1797.51n 0.0v 1847.49n 0.0v 1847.51n 0.0v 1897.49n 0.0v 1897.51n 0.0v 1947.49n 0.0v 1947.51n 1.8v 1997.49n 1.8v 1997.51n 1.8v 2047.49n 1.8v 2047.51n 1.8v 2097.49n 1.8v 2097.51n 0.0v 2147.49n 0.0v 2147.51n 1.8v 2197.49n 1.8v 2197.51n 0.0v 2247.49n 0.0v 2247.51n 0.0v 2297.49n 0.0v 2297.51n 0.0v 2347.49n 0.0v 2347.51n 0.0v 2397.49n 0.0v 2397.51n 0.0v 2447.49n 0.0v 2447.51n 0.0v 2497.49n 0.0v 2497.51n 1.8v 2547.49n 1.8v 2547.51n 0.0v 2597.49n 0.0v 2597.51n 1.8v 2647.49n 1.8v 2647.51n 0.0v 2697.49n 0.0v 2697.51n 0.0v 2747.49n 0.0v 2747.51n 1.8v 2797.49n 1.8v 2797.51n 1.8v 2847.49n 1.8v 2847.51n 0.0v 2897.49n 0.0v 2897.51n 0.0v 2947.49n 0.0v 2947.51n 1.8v 2997.49n 1.8v 2997.51n 1.8v 3047.49n 1.8v 3047.51n 0.0v 3097.49n 0.0v 3097.51n 0.0v 3147.49n 0.0v 3147.51n 0.0v 3197.49n 0.0v 3197.51n 0.0v 3247.49n 0.0v 3247.51n 0.0v 3297.49n 0.0v 3297.51n 0.0v 3347.49n 0.0v 3347.51n 0.0v 3397.49n 0.0v 3397.51n 0.0v 3447.49n 0.0v 3447.51n 1.8v 3497.49n 1.8v 3497.51n 1.8v 3547.49n 1.8v 3547.51n 1.8v 3597.49n 1.8v 3597.51n 1.8v 3647.49n 1.8v 3647.51n 0.0v 3697.49n 0.0v 3697.51n 0.0v 3747.49n 0.0v 3747.51n 1.8v 3797.49n 1.8v 3797.51n 1.8v 3847.49n 1.8v 3847.51n 1.8v 3897.49n 1.8v 3897.51n 1.8v 3947.49n 1.8v 3947.51n 1.8v 3997.49n 1.8v 3997.51n 1.8v 4047.49n 1.8v 4047.51n 1.8v 4097.49n 1.8v 4097.51n 1.8v 4147.49n 1.8v 4147.51n 1.8v 4197.49n 1.8v 4197.51n 1.8v 4247.49n 1.8v 4247.51n 1.8v 4297.49n 1.8v 4297.51n 0.0v 4347.49n 0.0v 4347.51n 0.0v 4397.49n 0.0v 4397.51n 1.8v 4447.49n 1.8v 4447.51n 1.8v 4497.49n 1.8v 4497.51n 1.8v 4547.49n 1.8v 4547.51n 0.0v 4597.49n 0.0v 4597.51n 0.0v 4647.49n 0.0v 4647.51n 0.0v 4697.49n 0.0v 4697.51n 1.8v 4747.49n 1.8v 4747.51n 0.0v 4797.49n 0.0v 4797.51n 0.0v 4847.49n 0.0v 4847.51n 0.0v 4897.49n 0.0v 4897.51n 1.8v 4947.49n 1.8v 4947.51n 1.8v 4997.49n 1.8v 4997.51n 0.0v 5047.49n 0.0v 5047.51n 0.0v 5097.49n 0.0v 5097.51n 0.0v 5147.49n 0.0v 5147.51n 1.8v 5197.49n 1.8v 5197.51n 1.8v 5247.49n 1.8v 5247.51n 0.0v 5297.49n 0.0v 5297.51n 0.0v 5347.49n 0.0v 5347.51n 0.0v 5397.49n 0.0v 5397.51n 0.0v 5447.49n 0.0v 5447.51n 1.8v 5497.49n 1.8v 5497.51n 1.8v 5547.49n 1.8v 5547.51n 0.0v 5597.49n 0.0v 5597.51n 0.0v 5647.49n 0.0v 5647.51n 0.0v 5697.49n 0.0v 5697.51n 0.0v 5747.49n 0.0v 5747.51n 1.8v 5797.49n 1.8v 5797.51n 1.8v 5847.49n 1.8v 5847.51n 1.8v 5897.49n 1.8v 5897.51n 0.0v 5947.49n 0.0v 5947.51n 0.0v 5997.49n 0.0v 5997.51n 1.8v 6047.49n 1.8v 6047.51n 1.8v 6097.49n 1.8v 6097.51n 1.8v 6147.49n 1.8v 6147.51n 0.0v 6197.49n 0.0v 6197.51n 1.8v 6247.49n 1.8v 6247.51n 1.8v 6297.49n 1.8v 6297.51n 0.0v 6347.49n 0.0v 6347.51n 0.0v 6397.49n 0.0v 6397.51n 0.0v 6447.49n 0.0v 6447.51n 1.8v 6497.49n 1.8v 6497.51n 0.0v 6547.49n 0.0v 6547.51n 1.8v 6597.49n 1.8v 6597.51n 1.8v 6647.49n 1.8v 6647.51n 1.8v 6697.49n 1.8v 6697.51n 0.0v 6747.49n 0.0v 6747.51n 0.0v 6797.49n 0.0v 6797.51n 0.0v 6847.49n 0.0v 6847.51n 0.0v 6897.49n 0.0v 6897.51n 0.0v 6947.49n 0.0v 6947.51n 0.0v 6997.49n 0.0v 6997.51n 1.8v 7047.49n 1.8v 7047.51n 1.8v 7097.49n 1.8v 7097.51n 1.8v 7147.49n 1.8v 7147.51n 1.8v 7197.49n 1.8v 7197.51n 0.0v 7247.49n 0.0v 7247.51n 0.0v 7297.49n 0.0v 7297.51n 0.0v 7347.49n 0.0v 7347.51n 1.8v 7397.49n 1.8v 7397.51n 0.0v 7447.49n 0.0v 7447.51n 1.8v 7497.49n 1.8v 7497.51n 0.0v 7547.49n 0.0v 7547.51n 1.8v 7597.49n 1.8v 7597.51n 0.0v 7647.49n 0.0v 7647.51n 1.8v 7697.49n 1.8v 7697.51n 1.8v 7747.49n 1.8v 7747.51n 0.0v 7797.49n 0.0v 7797.51n 0.0v 7847.49n 0.0v 7847.51n 1.8v 7897.49n 1.8v 7897.51n 0.0v 7947.49n 0.0v 7947.51n 1.8v 7997.49n 1.8v 7997.51n 0.0v 8047.49n 0.0v 8047.51n 1.8v 8097.49n 1.8v 8097.51n 0.0v 8147.49n 0.0v 8147.51n 1.8v 8197.49n 1.8v 8197.51n 1.8v 8247.49n 1.8v 8247.51n 1.8v 8297.49n 1.8v 8297.51n 0.0v 8347.49n 0.0v 8347.51n 0.0v 8397.49n 0.0v 8397.51n 0.0v 8447.49n 0.0v 8447.51n 0.0v 8497.49n 0.0v 8497.51n 0.0v 8547.49n 0.0v 8547.51n 0.0v 8597.49n 0.0v 8597.51n 0.0v 8647.49n 0.0v 8647.51n 1.8v 8697.49n 1.8v 8697.51n 0.0v 8747.49n 0.0v 8747.51n 0.0v 8797.49n 0.0v 8797.51n 1.8v 8847.49n 1.8v 8847.51n 0.0v 8897.49n 0.0v 8897.51n 1.8v 8947.49n 1.8v 8947.51n 1.8v 8997.49n 1.8v 8997.51n 0.0v 9047.49n 0.0v 9047.51n 0.0v 9097.49n 0.0v 9097.51n 0.0v 9147.49n 0.0v 9147.51n 1.8v 9197.49n 1.8v 9197.51n 0.0v 9247.49n 0.0v 9247.51n 0.0v 9297.49n 0.0v 9297.51n 1.8v 9347.49n 1.8v 9347.51n 1.8v 9397.49n 1.8v 9397.51n 1.8v 9447.49n 1.8v 9447.51n 1.8v 9497.49n 1.8v 9497.51n 1.8v 9547.49n 1.8v 9547.51n 1.8v 9597.49n 1.8v 9597.51n 1.8v 9647.49n 1.8v 9647.51n 1.8v 9697.49n 1.8v 9697.51n 1.8v 9747.49n 1.8v 9747.51n 1.8v 9797.49n 1.8v 9797.51n 1.8v 9847.49n 1.8v 9847.51n 0.0v 9897.49n 0.0v 9897.51n 0.0v 9947.49n 0.0v 9947.51n 0.0v 9997.49n 0.0v 9997.51n 1.8v 10047.49n 1.8v 10047.51n 0.0v 10097.49n 0.0v 10097.51n 1.8v 10147.49n 1.8v 10147.51n 1.8v 10197.49n 1.8v 10197.51n 1.8v 10247.49n 1.8v 10247.51n 1.8v )

 * Generation of control signals
* (time, data): [(0, 1), (50, 0), (100, 0), (150, 0), (200, 0), (250, 0), (300, 1), (350, 0), (400, 0), (450, 0), (500, 1), (550, 1), (600, 0), (650, 0), (700, 1), (750, 0), (800, 1), (850, 0), (900, 0), (950, 0), (1000, 1), (1050, 0), (1100, 1), (1150, 0), (1200, 1), (1250, 0), (1300, 0), (1350, 0), (1400, 0), (1450, 0), (1500, 0), (1550, 0), (1600, 0), (1650, 0), (1700, 0), (1750, 0), (1800, 0), (1850, 1), (1900, 1), (1950, 0), (2000, 0), (2050, 0), (2100, 0), (2150, 0), (2200, 0), (2250, 0), (2300, 1), (2350, 1), (2400, 0), (2450, 1), (2500, 0), (2550, 0), (2600, 0), (2650, 0), (2700, 1), (2750, 0), (2800, 0), (2850, 0), (2900, 1), (2950, 0), (3000, 1), (3050, 0), (3100, 0), (3150, 1), (3200, 0), (3250, 1), (3300, 1), (3350, 0), (3400, 0), (3450, 0), (3500, 1), (3550, 1), (3600, 1), (3650, 0), (3700, 0), (3750, 0), (3800, 0), (3850, 1), (3900, 0), (3950, 0), (4000, 1), (4050, 0), (4100, 0), (4150, 1), (4200, 1), (4250, 1), (4300, 0), (4350, 0), (4400, 0), (4450, 1), (4500, 0), (4550, 0), (4600, 1), (4650, 0), (4700, 0), (4750, 0), (4800, 0), (4850, 1), (4900, 0), (4950, 0), (5000, 0), (5050, 0), (5100, 1), (5150, 0), (5200, 1), (5250, 0), (5300, 0), (5350, 0), (5400, 1), (5450, 0), (5500, 0), (5550, 0), (5600, 0), (5650, 1), (5700, 1), (5750, 0), (5800, 0), (5850, 1), (5900, 0), (5950, 0), (6000, 0), (6050, 0), (6100, 0), (6150, 0), (6200, 0), (6250, 0), (6300, 0), (6350, 0), (6400, 0), (6450, 0), (6500, 0), (6550, 0), (6600, 0), (6650, 0), (6700, 0), (6750, 0), (6800, 1), (6850, 1), (6900, 0), (6950, 1), (7000, 0), (7050, 1), (7100, 1), (7150, 0), (7200, 0), (7250, 0), (7300, 1), (7350, 0), (7400, 0), (7450, 0), (7500, 0), (7550, 0), (7600, 0), (7650, 0), (7700, 0), (7750, 0), (7800, 0), (7850, 0), (7900, 0), (7950, 0), (8000, 0), (8050, 0), (8100, 0), (8150, 0), (8200, 0), (8250, 0), (8300, 0), (8350, 0), (8400, 1), (8450, 0), (8500, 0), (8550, 0), (8600, 1), (8650, 0), (8700, 0), (8750, 0), (8800, 0), (8850, 0), (8900, 0), (8950, 0), (9000, 0), (9050, 0), (9100, 1), (9150, 0), (9200, 0), (9250, 0), (9300, 0), (9350, 1), (9400, 0), (9450, 1), (9500, 0), (9550, 0), (9600, 0), (9650, 1), (9700, 0), (9750, 0), (9800, 0), (9850, 0), (9900, 0), (9950, 0), (10000, 0), (10050, 0), (10100, 0), (10150, 0), (10200, 1), (10250, 1)]
VCSB0 CSB0 0 PWL (0n 1.8v 47.49n 1.8v 47.51n 0.0v 97.49n 0.0v 97.51n 0.0v 147.49n 0.0v 147.51n 0.0v 197.49n 0.0v 197.51n 0.0v 247.49n 0.0v 247.51n 0.0v 297.49n 0.0v 297.51n 1.8v 347.49n 1.8v 347.51n 0.0v 397.49n 0.0v 397.51n 0.0v 447.49n 0.0v 447.51n 0.0v 497.49n 0.0v 497.51n 1.8v 547.49n 1.8v 547.51n 1.8v 597.49n 1.8v 597.51n 0.0v 647.49n 0.0v 647.51n 0.0v 697.49n 0.0v 697.51n 1.8v 747.49n 1.8v 747.51n 0.0v 797.49n 0.0v 797.51n 1.8v 847.49n 1.8v 847.51n 0.0v 897.49n 0.0v 897.51n 0.0v 947.49n 0.0v 947.51n 0.0v 997.49n 0.0v 997.51n 1.8v 1047.49n 1.8v 1047.51n 0.0v 1097.49n 0.0v 1097.51n 1.8v 1147.49n 1.8v 1147.51n 0.0v 1197.49n 0.0v 1197.51n 1.8v 1247.49n 1.8v 1247.51n 0.0v 1297.49n 0.0v 1297.51n 0.0v 1347.49n 0.0v 1347.51n 0.0v 1397.49n 0.0v 1397.51n 0.0v 1447.49n 0.0v 1447.51n 0.0v 1497.49n 0.0v 1497.51n 0.0v 1547.49n 0.0v 1547.51n 0.0v 1597.49n 0.0v 1597.51n 0.0v 1647.49n 0.0v 1647.51n 0.0v 1697.49n 0.0v 1697.51n 0.0v 1747.49n 0.0v 1747.51n 0.0v 1797.49n 0.0v 1797.51n 0.0v 1847.49n 0.0v 1847.51n 1.8v 1897.49n 1.8v 1897.51n 1.8v 1947.49n 1.8v 1947.51n 0.0v 1997.49n 0.0v 1997.51n 0.0v 2047.49n 0.0v 2047.51n 0.0v 2097.49n 0.0v 2097.51n 0.0v 2147.49n 0.0v 2147.51n 0.0v 2197.49n 0.0v 2197.51n 0.0v 2247.49n 0.0v 2247.51n 0.0v 2297.49n 0.0v 2297.51n 1.8v 2347.49n 1.8v 2347.51n 1.8v 2397.49n 1.8v 2397.51n 0.0v 2447.49n 0.0v 2447.51n 1.8v 2497.49n 1.8v 2497.51n 0.0v 2547.49n 0.0v 2547.51n 0.0v 2597.49n 0.0v 2597.51n 0.0v 2647.49n 0.0v 2647.51n 0.0v 2697.49n 0.0v 2697.51n 1.8v 2747.49n 1.8v 2747.51n 0.0v 2797.49n 0.0v 2797.51n 0.0v 2847.49n 0.0v 2847.51n 0.0v 2897.49n 0.0v 2897.51n 1.8v 2947.49n 1.8v 2947.51n 0.0v 2997.49n 0.0v 2997.51n 1.8v 3047.49n 1.8v 3047.51n 0.0v 3097.49n 0.0v 3097.51n 0.0v 3147.49n 0.0v 3147.51n 1.8v 3197.49n 1.8v 3197.51n 0.0v 3247.49n 0.0v 3247.51n 1.8v 3297.49n 1.8v 3297.51n 1.8v 3347.49n 1.8v 3347.51n 0.0v 3397.49n 0.0v 3397.51n 0.0v 3447.49n 0.0v 3447.51n 0.0v 3497.49n 0.0v 3497.51n 1.8v 3547.49n 1.8v 3547.51n 1.8v 3597.49n 1.8v 3597.51n 1.8v 3647.49n 1.8v 3647.51n 0.0v 3697.49n 0.0v 3697.51n 0.0v 3747.49n 0.0v 3747.51n 0.0v 3797.49n 0.0v 3797.51n 0.0v 3847.49n 0.0v 3847.51n 1.8v 3897.49n 1.8v 3897.51n 0.0v 3947.49n 0.0v 3947.51n 0.0v 3997.49n 0.0v 3997.51n 1.8v 4047.49n 1.8v 4047.51n 0.0v 4097.49n 0.0v 4097.51n 0.0v 4147.49n 0.0v 4147.51n 1.8v 4197.49n 1.8v 4197.51n 1.8v 4247.49n 1.8v 4247.51n 1.8v 4297.49n 1.8v 4297.51n 0.0v 4347.49n 0.0v 4347.51n 0.0v 4397.49n 0.0v 4397.51n 0.0v 4447.49n 0.0v 4447.51n 1.8v 4497.49n 1.8v 4497.51n 0.0v 4547.49n 0.0v 4547.51n 0.0v 4597.49n 0.0v 4597.51n 1.8v 4647.49n 1.8v 4647.51n 0.0v 4697.49n 0.0v 4697.51n 0.0v 4747.49n 0.0v 4747.51n 0.0v 4797.49n 0.0v 4797.51n 0.0v 4847.49n 0.0v 4847.51n 1.8v 4897.49n 1.8v 4897.51n 0.0v 4947.49n 0.0v 4947.51n 0.0v 4997.49n 0.0v 4997.51n 0.0v 5047.49n 0.0v 5047.51n 0.0v 5097.49n 0.0v 5097.51n 1.8v 5147.49n 1.8v 5147.51n 0.0v 5197.49n 0.0v 5197.51n 1.8v 5247.49n 1.8v 5247.51n 0.0v 5297.49n 0.0v 5297.51n 0.0v 5347.49n 0.0v 5347.51n 0.0v 5397.49n 0.0v 5397.51n 1.8v 5447.49n 1.8v 5447.51n 0.0v 5497.49n 0.0v 5497.51n 0.0v 5547.49n 0.0v 5547.51n 0.0v 5597.49n 0.0v 5597.51n 0.0v 5647.49n 0.0v 5647.51n 1.8v 5697.49n 1.8v 5697.51n 1.8v 5747.49n 1.8v 5747.51n 0.0v 5797.49n 0.0v 5797.51n 0.0v 5847.49n 0.0v 5847.51n 1.8v 5897.49n 1.8v 5897.51n 0.0v 5947.49n 0.0v 5947.51n 0.0v 5997.49n 0.0v 5997.51n 0.0v 6047.49n 0.0v 6047.51n 0.0v 6097.49n 0.0v 6097.51n 0.0v 6147.49n 0.0v 6147.51n 0.0v 6197.49n 0.0v 6197.51n 0.0v 6247.49n 0.0v 6247.51n 0.0v 6297.49n 0.0v 6297.51n 0.0v 6347.49n 0.0v 6347.51n 0.0v 6397.49n 0.0v 6397.51n 0.0v 6447.49n 0.0v 6447.51n 0.0v 6497.49n 0.0v 6497.51n 0.0v 6547.49n 0.0v 6547.51n 0.0v 6597.49n 0.0v 6597.51n 0.0v 6647.49n 0.0v 6647.51n 0.0v 6697.49n 0.0v 6697.51n 0.0v 6747.49n 0.0v 6747.51n 0.0v 6797.49n 0.0v 6797.51n 1.8v 6847.49n 1.8v 6847.51n 1.8v 6897.49n 1.8v 6897.51n 0.0v 6947.49n 0.0v 6947.51n 1.8v 6997.49n 1.8v 6997.51n 0.0v 7047.49n 0.0v 7047.51n 1.8v 7097.49n 1.8v 7097.51n 1.8v 7147.49n 1.8v 7147.51n 0.0v 7197.49n 0.0v 7197.51n 0.0v 7247.49n 0.0v 7247.51n 0.0v 7297.49n 0.0v 7297.51n 1.8v 7347.49n 1.8v 7347.51n 0.0v 7397.49n 0.0v 7397.51n 0.0v 7447.49n 0.0v 7447.51n 0.0v 7497.49n 0.0v 7497.51n 0.0v 7547.49n 0.0v 7547.51n 0.0v 7597.49n 0.0v 7597.51n 0.0v 7647.49n 0.0v 7647.51n 0.0v 7697.49n 0.0v 7697.51n 0.0v 7747.49n 0.0v 7747.51n 0.0v 7797.49n 0.0v 7797.51n 0.0v 7847.49n 0.0v 7847.51n 0.0v 7897.49n 0.0v 7897.51n 0.0v 7947.49n 0.0v 7947.51n 0.0v 7997.49n 0.0v 7997.51n 0.0v 8047.49n 0.0v 8047.51n 0.0v 8097.49n 0.0v 8097.51n 0.0v 8147.49n 0.0v 8147.51n 0.0v 8197.49n 0.0v 8197.51n 0.0v 8247.49n 0.0v 8247.51n 0.0v 8297.49n 0.0v 8297.51n 0.0v 8347.49n 0.0v 8347.51n 0.0v 8397.49n 0.0v 8397.51n 1.8v 8447.49n 1.8v 8447.51n 0.0v 8497.49n 0.0v 8497.51n 0.0v 8547.49n 0.0v 8547.51n 0.0v 8597.49n 0.0v 8597.51n 1.8v 8647.49n 1.8v 8647.51n 0.0v 8697.49n 0.0v 8697.51n 0.0v 8747.49n 0.0v 8747.51n 0.0v 8797.49n 0.0v 8797.51n 0.0v 8847.49n 0.0v 8847.51n 0.0v 8897.49n 0.0v 8897.51n 0.0v 8947.49n 0.0v 8947.51n 0.0v 8997.49n 0.0v 8997.51n 0.0v 9047.49n 0.0v 9047.51n 0.0v 9097.49n 0.0v 9097.51n 1.8v 9147.49n 1.8v 9147.51n 0.0v 9197.49n 0.0v 9197.51n 0.0v 9247.49n 0.0v 9247.51n 0.0v 9297.49n 0.0v 9297.51n 0.0v 9347.49n 0.0v 9347.51n 1.8v 9397.49n 1.8v 9397.51n 0.0v 9447.49n 0.0v 9447.51n 1.8v 9497.49n 1.8v 9497.51n 0.0v 9547.49n 0.0v 9547.51n 0.0v 9597.49n 0.0v 9597.51n 0.0v 9647.49n 0.0v 9647.51n 1.8v 9697.49n 1.8v 9697.51n 0.0v 9747.49n 0.0v 9747.51n 0.0v 9797.49n 0.0v 9797.51n 0.0v 9847.49n 0.0v 9847.51n 0.0v 9897.49n 0.0v 9897.51n 0.0v 9947.49n 0.0v 9947.51n 0.0v 9997.49n 0.0v 9997.51n 0.0v 10047.49n 0.0v 10047.51n 0.0v 10097.49n 0.0v 10097.51n 0.0v 10147.49n 0.0v 10147.51n 0.0v 10197.49n 0.0v 10197.51n 1.8v 10247.49n 1.8v 10247.51n 1.8v )
* (time, data): [(0, 1), (50, 0), (100, 0), (150, 0), (200, 1), (250, 1), (300, 1), (350, 0), (400, 1), (450, 0), (500, 1), (550, 1), (600, 1), (650, 0), (700, 1), (750, 1), (800, 1), (850, 1), (900, 1), (950, 1), (1000, 1), (1050, 0), (1100, 1), (1150, 0), (1200, 1), (1250, 1), (1300, 1), (1350, 1), (1400, 0), (1450, 1), (1500, 0), (1550, 1), (1600, 0), (1650, 1), (1700, 1), (1750, 1), (1800, 0), (1850, 1), (1900, 1), (1950, 0), (2000, 1), (2050, 1), (2100, 1), (2150, 1), (2200, 1), (2250, 0), (2300, 1), (2350, 1), (2400, 1), (2450, 1), (2500, 1), (2550, 1), (2600, 1), (2650, 1), (2700, 1), (2750, 1), (2800, 0), (2850, 0), (2900, 1), (2950, 1), (3000, 1), (3050, 1), (3100, 0), (3150, 1), (3200, 0), (3250, 1), (3300, 1), (3350, 1), (3400, 1), (3450, 0), (3500, 1), (3550, 1), (3600, 1), (3650, 0), (3700, 1), (3750, 1), (3800, 1), (3850, 1), (3900, 1), (3950, 1), (4000, 1), (4050, 1), (4100, 0), (4150, 1), (4200, 1), (4250, 1), (4300, 1), (4350, 1), (4400, 1), (4450, 1), (4500, 0), (4550, 1), (4600, 1), (4650, 1), (4700, 1), (4750, 0), (4800, 0), (4850, 1), (4900, 0), (4950, 1), (5000, 1), (5050, 1), (5100, 1), (5150, 1), (5200, 1), (5250, 1), (5300, 0), (5350, 1), (5400, 1), (5450, 1), (5500, 0), (5550, 1), (5600, 0), (5650, 1), (5700, 1), (5750, 0), (5800, 1), (5850, 1), (5900, 1), (5950, 0), (6000, 0), (6050, 1), (6100, 0), (6150, 1), (6200, 1), (6250, 1), (6300, 1), (6350, 0), (6400, 1), (6450, 1), (6500, 1), (6550, 1), (6600, 0), (6650, 1), (6700, 1), (6750, 1), (6800, 1), (6850, 1), (6900, 1), (6950, 1), (7000, 1), (7050, 1), (7100, 1), (7150, 1), (7200, 0), (7250, 1), (7300, 1), (7350, 1), (7400, 1), (7450, 0), (7500, 0), (7550, 1), (7600, 1), (7650, 1), (7700, 0), (7750, 1), (7800, 0), (7850, 0), (7900, 1), (7950, 0), (8000, 1), (8050, 0), (8100, 1), (8150, 0), (8200, 1), (8250, 1), (8300, 1), (8350, 1), (8400, 1), (8450, 0), (8500, 1), (8550, 1), (8600, 1), (8650, 1), (8700, 1), (8750, 0), (8800, 1), (8850, 1), (8900, 0), (8950, 1), (9000, 0), (9050, 0), (9100, 1), (9150, 1), (9200, 1), (9250, 1), (9300, 1), (9350, 1), (9400, 0), (9450, 1), (9500, 1), (9550, 1), (9600, 0), (9650, 1), (9700, 1), (9750, 1), (9800, 1), (9850, 1), (9900, 1), (9950, 1), (10000, 0), (10050, 1), (10100, 1), (10150, 0), (10200, 1), (10250, 1)]
VWEB0 WEB0 0 PWL (0n 1.8v 47.49n 1.8v 47.51n 0.0v 97.49n 0.0v 97.51n 0.0v 147.49n 0.0v 147.51n 0.0v 197.49n 0.0v 197.51n 1.8v 247.49n 1.8v 247.51n 1.8v 297.49n 1.8v 297.51n 1.8v 347.49n 1.8v 347.51n 0.0v 397.49n 0.0v 397.51n 1.8v 447.49n 1.8v 447.51n 0.0v 497.49n 0.0v 497.51n 1.8v 547.49n 1.8v 547.51n 1.8v 597.49n 1.8v 597.51n 1.8v 647.49n 1.8v 647.51n 0.0v 697.49n 0.0v 697.51n 1.8v 747.49n 1.8v 747.51n 1.8v 797.49n 1.8v 797.51n 1.8v 847.49n 1.8v 847.51n 1.8v 897.49n 1.8v 897.51n 1.8v 947.49n 1.8v 947.51n 1.8v 997.49n 1.8v 997.51n 1.8v 1047.49n 1.8v 1047.51n 0.0v 1097.49n 0.0v 1097.51n 1.8v 1147.49n 1.8v 1147.51n 0.0v 1197.49n 0.0v 1197.51n 1.8v 1247.49n 1.8v 1247.51n 1.8v 1297.49n 1.8v 1297.51n 1.8v 1347.49n 1.8v 1347.51n 1.8v 1397.49n 1.8v 1397.51n 0.0v 1447.49n 0.0v 1447.51n 1.8v 1497.49n 1.8v 1497.51n 0.0v 1547.49n 0.0v 1547.51n 1.8v 1597.49n 1.8v 1597.51n 0.0v 1647.49n 0.0v 1647.51n 1.8v 1697.49n 1.8v 1697.51n 1.8v 1747.49n 1.8v 1747.51n 1.8v 1797.49n 1.8v 1797.51n 0.0v 1847.49n 0.0v 1847.51n 1.8v 1897.49n 1.8v 1897.51n 1.8v 1947.49n 1.8v 1947.51n 0.0v 1997.49n 0.0v 1997.51n 1.8v 2047.49n 1.8v 2047.51n 1.8v 2097.49n 1.8v 2097.51n 1.8v 2147.49n 1.8v 2147.51n 1.8v 2197.49n 1.8v 2197.51n 1.8v 2247.49n 1.8v 2247.51n 0.0v 2297.49n 0.0v 2297.51n 1.8v 2347.49n 1.8v 2347.51n 1.8v 2397.49n 1.8v 2397.51n 1.8v 2447.49n 1.8v 2447.51n 1.8v 2497.49n 1.8v 2497.51n 1.8v 2547.49n 1.8v 2547.51n 1.8v 2597.49n 1.8v 2597.51n 1.8v 2647.49n 1.8v 2647.51n 1.8v 2697.49n 1.8v 2697.51n 1.8v 2747.49n 1.8v 2747.51n 1.8v 2797.49n 1.8v 2797.51n 0.0v 2847.49n 0.0v 2847.51n 0.0v 2897.49n 0.0v 2897.51n 1.8v 2947.49n 1.8v 2947.51n 1.8v 2997.49n 1.8v 2997.51n 1.8v 3047.49n 1.8v 3047.51n 1.8v 3097.49n 1.8v 3097.51n 0.0v 3147.49n 0.0v 3147.51n 1.8v 3197.49n 1.8v 3197.51n 0.0v 3247.49n 0.0v 3247.51n 1.8v 3297.49n 1.8v 3297.51n 1.8v 3347.49n 1.8v 3347.51n 1.8v 3397.49n 1.8v 3397.51n 1.8v 3447.49n 1.8v 3447.51n 0.0v 3497.49n 0.0v 3497.51n 1.8v 3547.49n 1.8v 3547.51n 1.8v 3597.49n 1.8v 3597.51n 1.8v 3647.49n 1.8v 3647.51n 0.0v 3697.49n 0.0v 3697.51n 1.8v 3747.49n 1.8v 3747.51n 1.8v 3797.49n 1.8v 3797.51n 1.8v 3847.49n 1.8v 3847.51n 1.8v 3897.49n 1.8v 3897.51n 1.8v 3947.49n 1.8v 3947.51n 1.8v 3997.49n 1.8v 3997.51n 1.8v 4047.49n 1.8v 4047.51n 1.8v 4097.49n 1.8v 4097.51n 0.0v 4147.49n 0.0v 4147.51n 1.8v 4197.49n 1.8v 4197.51n 1.8v 4247.49n 1.8v 4247.51n 1.8v 4297.49n 1.8v 4297.51n 1.8v 4347.49n 1.8v 4347.51n 1.8v 4397.49n 1.8v 4397.51n 1.8v 4447.49n 1.8v 4447.51n 1.8v 4497.49n 1.8v 4497.51n 0.0v 4547.49n 0.0v 4547.51n 1.8v 4597.49n 1.8v 4597.51n 1.8v 4647.49n 1.8v 4647.51n 1.8v 4697.49n 1.8v 4697.51n 1.8v 4747.49n 1.8v 4747.51n 0.0v 4797.49n 0.0v 4797.51n 0.0v 4847.49n 0.0v 4847.51n 1.8v 4897.49n 1.8v 4897.51n 0.0v 4947.49n 0.0v 4947.51n 1.8v 4997.49n 1.8v 4997.51n 1.8v 5047.49n 1.8v 5047.51n 1.8v 5097.49n 1.8v 5097.51n 1.8v 5147.49n 1.8v 5147.51n 1.8v 5197.49n 1.8v 5197.51n 1.8v 5247.49n 1.8v 5247.51n 1.8v 5297.49n 1.8v 5297.51n 0.0v 5347.49n 0.0v 5347.51n 1.8v 5397.49n 1.8v 5397.51n 1.8v 5447.49n 1.8v 5447.51n 1.8v 5497.49n 1.8v 5497.51n 0.0v 5547.49n 0.0v 5547.51n 1.8v 5597.49n 1.8v 5597.51n 0.0v 5647.49n 0.0v 5647.51n 1.8v 5697.49n 1.8v 5697.51n 1.8v 5747.49n 1.8v 5747.51n 0.0v 5797.49n 0.0v 5797.51n 1.8v 5847.49n 1.8v 5847.51n 1.8v 5897.49n 1.8v 5897.51n 1.8v 5947.49n 1.8v 5947.51n 0.0v 5997.49n 0.0v 5997.51n 0.0v 6047.49n 0.0v 6047.51n 1.8v 6097.49n 1.8v 6097.51n 0.0v 6147.49n 0.0v 6147.51n 1.8v 6197.49n 1.8v 6197.51n 1.8v 6247.49n 1.8v 6247.51n 1.8v 6297.49n 1.8v 6297.51n 1.8v 6347.49n 1.8v 6347.51n 0.0v 6397.49n 0.0v 6397.51n 1.8v 6447.49n 1.8v 6447.51n 1.8v 6497.49n 1.8v 6497.51n 1.8v 6547.49n 1.8v 6547.51n 1.8v 6597.49n 1.8v 6597.51n 0.0v 6647.49n 0.0v 6647.51n 1.8v 6697.49n 1.8v 6697.51n 1.8v 6747.49n 1.8v 6747.51n 1.8v 6797.49n 1.8v 6797.51n 1.8v 6847.49n 1.8v 6847.51n 1.8v 6897.49n 1.8v 6897.51n 1.8v 6947.49n 1.8v 6947.51n 1.8v 6997.49n 1.8v 6997.51n 1.8v 7047.49n 1.8v 7047.51n 1.8v 7097.49n 1.8v 7097.51n 1.8v 7147.49n 1.8v 7147.51n 1.8v 7197.49n 1.8v 7197.51n 0.0v 7247.49n 0.0v 7247.51n 1.8v 7297.49n 1.8v 7297.51n 1.8v 7347.49n 1.8v 7347.51n 1.8v 7397.49n 1.8v 7397.51n 1.8v 7447.49n 1.8v 7447.51n 0.0v 7497.49n 0.0v 7497.51n 0.0v 7547.49n 0.0v 7547.51n 1.8v 7597.49n 1.8v 7597.51n 1.8v 7647.49n 1.8v 7647.51n 1.8v 7697.49n 1.8v 7697.51n 0.0v 7747.49n 0.0v 7747.51n 1.8v 7797.49n 1.8v 7797.51n 0.0v 7847.49n 0.0v 7847.51n 0.0v 7897.49n 0.0v 7897.51n 1.8v 7947.49n 1.8v 7947.51n 0.0v 7997.49n 0.0v 7997.51n 1.8v 8047.49n 1.8v 8047.51n 0.0v 8097.49n 0.0v 8097.51n 1.8v 8147.49n 1.8v 8147.51n 0.0v 8197.49n 0.0v 8197.51n 1.8v 8247.49n 1.8v 8247.51n 1.8v 8297.49n 1.8v 8297.51n 1.8v 8347.49n 1.8v 8347.51n 1.8v 8397.49n 1.8v 8397.51n 1.8v 8447.49n 1.8v 8447.51n 0.0v 8497.49n 0.0v 8497.51n 1.8v 8547.49n 1.8v 8547.51n 1.8v 8597.49n 1.8v 8597.51n 1.8v 8647.49n 1.8v 8647.51n 1.8v 8697.49n 1.8v 8697.51n 1.8v 8747.49n 1.8v 8747.51n 0.0v 8797.49n 0.0v 8797.51n 1.8v 8847.49n 1.8v 8847.51n 1.8v 8897.49n 1.8v 8897.51n 0.0v 8947.49n 0.0v 8947.51n 1.8v 8997.49n 1.8v 8997.51n 0.0v 9047.49n 0.0v 9047.51n 0.0v 9097.49n 0.0v 9097.51n 1.8v 9147.49n 1.8v 9147.51n 1.8v 9197.49n 1.8v 9197.51n 1.8v 9247.49n 1.8v 9247.51n 1.8v 9297.49n 1.8v 9297.51n 1.8v 9347.49n 1.8v 9347.51n 1.8v 9397.49n 1.8v 9397.51n 0.0v 9447.49n 0.0v 9447.51n 1.8v 9497.49n 1.8v 9497.51n 1.8v 9547.49n 1.8v 9547.51n 1.8v 9597.49n 1.8v 9597.51n 0.0v 9647.49n 0.0v 9647.51n 1.8v 9697.49n 1.8v 9697.51n 1.8v 9747.49n 1.8v 9747.51n 1.8v 9797.49n 1.8v 9797.51n 1.8v 9847.49n 1.8v 9847.51n 1.8v 9897.49n 1.8v 9897.51n 1.8v 9947.49n 1.8v 9947.51n 1.8v 9997.49n 1.8v 9997.51n 0.0v 10047.49n 0.0v 10047.51n 1.8v 10097.49n 1.8v 10097.51n 1.8v 10147.49n 1.8v 10147.51n 0.0v 10197.49n 0.0v 10197.51n 1.8v 10247.49n 1.8v 10247.51n 1.8v )
* PULSE: period=50
Vclk0 clk0 0 PULSE (0 1.8 49.99n 0.02n 0.02n 24.979999999999997n 50n)

 * Generation of dout measurements
* CHECK dout0_0 Vdout0_0ck4 = 1.8 time = 250
.meas tran vdout0_0ck4 FIND v(dout0_0) AT=250.25n

* CHECK dout0_1 Vdout0_1ck4 = 1.8 time = 250
.meas tran vdout0_1ck4 FIND v(dout0_1) AT=250.25n

* CHECK dout0_2 Vdout0_2ck4 = 0 time = 250
.meas tran vdout0_2ck4 FIND v(dout0_2) AT=250.25n

* CHECK dout0_3 Vdout0_3ck4 = 0 time = 250
.meas tran vdout0_3ck4 FIND v(dout0_3) AT=250.25n

* CHECK dout0_4 Vdout0_4ck4 = 0 time = 250
.meas tran vdout0_4ck4 FIND v(dout0_4) AT=250.25n

* CHECK dout0_5 Vdout0_5ck4 = 0 time = 250
.meas tran vdout0_5ck4 FIND v(dout0_5) AT=250.25n

* CHECK dout0_6 Vdout0_6ck4 = 1.8 time = 250
.meas tran vdout0_6ck4 FIND v(dout0_6) AT=250.25n

* CHECK dout0_7 Vdout0_7ck4 = 0 time = 250
.meas tran vdout0_7ck4 FIND v(dout0_7) AT=250.25n

* CHECK dout0_8 Vdout0_8ck4 = 0 time = 250
.meas tran vdout0_8ck4 FIND v(dout0_8) AT=250.25n

* CHECK dout0_9 Vdout0_9ck4 = 0 time = 250
.meas tran vdout0_9ck4 FIND v(dout0_9) AT=250.25n

* CHECK dout0_10 Vdout0_10ck4 = 0 time = 250
.meas tran vdout0_10ck4 FIND v(dout0_10) AT=250.25n

* CHECK dout0_11 Vdout0_11ck4 = 0 time = 250
.meas tran vdout0_11ck4 FIND v(dout0_11) AT=250.25n

* CHECK dout0_12 Vdout0_12ck4 = 1.8 time = 250
.meas tran vdout0_12ck4 FIND v(dout0_12) AT=250.25n

* CHECK dout0_13 Vdout0_13ck4 = 0 time = 250
.meas tran vdout0_13ck4 FIND v(dout0_13) AT=250.25n

* CHECK dout0_14 Vdout0_14ck4 = 1.8 time = 250
.meas tran vdout0_14ck4 FIND v(dout0_14) AT=250.25n

* CHECK dout0_15 Vdout0_15ck4 = 1.8 time = 250
.meas tran vdout0_15ck4 FIND v(dout0_15) AT=250.25n

* CHECK dout0_0 Vdout0_0ck5 = 0 time = 300
.meas tran vdout0_0ck5 FIND v(dout0_0) AT=300.25n

* CHECK dout0_1 Vdout0_1ck5 = 0 time = 300
.meas tran vdout0_1ck5 FIND v(dout0_1) AT=300.25n

* CHECK dout0_2 Vdout0_2ck5 = 0 time = 300
.meas tran vdout0_2ck5 FIND v(dout0_2) AT=300.25n

* CHECK dout0_3 Vdout0_3ck5 = 0 time = 300
.meas tran vdout0_3ck5 FIND v(dout0_3) AT=300.25n

* CHECK dout0_4 Vdout0_4ck5 = 1.8 time = 300
.meas tran vdout0_4ck5 FIND v(dout0_4) AT=300.25n

* CHECK dout0_5 Vdout0_5ck5 = 0 time = 300
.meas tran vdout0_5ck5 FIND v(dout0_5) AT=300.25n

* CHECK dout0_6 Vdout0_6ck5 = 0 time = 300
.meas tran vdout0_6ck5 FIND v(dout0_6) AT=300.25n

* CHECK dout0_7 Vdout0_7ck5 = 1.8 time = 300
.meas tran vdout0_7ck5 FIND v(dout0_7) AT=300.25n

* CHECK dout0_8 Vdout0_8ck5 = 0 time = 300
.meas tran vdout0_8ck5 FIND v(dout0_8) AT=300.25n

* CHECK dout0_9 Vdout0_9ck5 = 0 time = 300
.meas tran vdout0_9ck5 FIND v(dout0_9) AT=300.25n

* CHECK dout0_10 Vdout0_10ck5 = 0 time = 300
.meas tran vdout0_10ck5 FIND v(dout0_10) AT=300.25n

* CHECK dout0_11 Vdout0_11ck5 = 0 time = 300
.meas tran vdout0_11ck5 FIND v(dout0_11) AT=300.25n

* CHECK dout0_12 Vdout0_12ck5 = 1.8 time = 300
.meas tran vdout0_12ck5 FIND v(dout0_12) AT=300.25n

* CHECK dout0_13 Vdout0_13ck5 = 0 time = 300
.meas tran vdout0_13ck5 FIND v(dout0_13) AT=300.25n

* CHECK dout0_14 Vdout0_14ck5 = 0 time = 300
.meas tran vdout0_14ck5 FIND v(dout0_14) AT=300.25n

* CHECK dout0_15 Vdout0_15ck5 = 0 time = 300
.meas tran vdout0_15ck5 FIND v(dout0_15) AT=300.25n

* CHECK dout0_0 Vdout0_0ck8 = 1.8 time = 450
.meas tran vdout0_0ck8 FIND v(dout0_0) AT=450.25n

* CHECK dout0_1 Vdout0_1ck8 = 0 time = 450
.meas tran vdout0_1ck8 FIND v(dout0_1) AT=450.25n

* CHECK dout0_2 Vdout0_2ck8 = 1.8 time = 450
.meas tran vdout0_2ck8 FIND v(dout0_2) AT=450.25n

* CHECK dout0_3 Vdout0_3ck8 = 0 time = 450
.meas tran vdout0_3ck8 FIND v(dout0_3) AT=450.25n

* CHECK dout0_4 Vdout0_4ck8 = 0 time = 450
.meas tran vdout0_4ck8 FIND v(dout0_4) AT=450.25n

* CHECK dout0_5 Vdout0_5ck8 = 0 time = 450
.meas tran vdout0_5ck8 FIND v(dout0_5) AT=450.25n

* CHECK dout0_6 Vdout0_6ck8 = 1.8 time = 450
.meas tran vdout0_6ck8 FIND v(dout0_6) AT=450.25n

* CHECK dout0_7 Vdout0_7ck8 = 0 time = 450
.meas tran vdout0_7ck8 FIND v(dout0_7) AT=450.25n

* CHECK dout0_8 Vdout0_8ck8 = 0 time = 450
.meas tran vdout0_8ck8 FIND v(dout0_8) AT=450.25n

* CHECK dout0_9 Vdout0_9ck8 = 0 time = 450
.meas tran vdout0_9ck8 FIND v(dout0_9) AT=450.25n

* CHECK dout0_10 Vdout0_10ck8 = 1.8 time = 450
.meas tran vdout0_10ck8 FIND v(dout0_10) AT=450.25n

* CHECK dout0_11 Vdout0_11ck8 = 0 time = 450
.meas tran vdout0_11ck8 FIND v(dout0_11) AT=450.25n

* CHECK dout0_12 Vdout0_12ck8 = 0 time = 450
.meas tran vdout0_12ck8 FIND v(dout0_12) AT=450.25n

* CHECK dout0_13 Vdout0_13ck8 = 0 time = 450
.meas tran vdout0_13ck8 FIND v(dout0_13) AT=450.25n

* CHECK dout0_14 Vdout0_14ck8 = 0 time = 450
.meas tran vdout0_14ck8 FIND v(dout0_14) AT=450.25n

* CHECK dout0_15 Vdout0_15ck8 = 0 time = 450
.meas tran vdout0_15ck8 FIND v(dout0_15) AT=450.25n

* CHECK dout0_0 Vdout0_0ck12 = 0 time = 650
.meas tran vdout0_0ck12 FIND v(dout0_0) AT=650.25n

* CHECK dout0_1 Vdout0_1ck12 = 0 time = 650
.meas tran vdout0_1ck12 FIND v(dout0_1) AT=650.25n

* CHECK dout0_2 Vdout0_2ck12 = 0 time = 650
.meas tran vdout0_2ck12 FIND v(dout0_2) AT=650.25n

* CHECK dout0_3 Vdout0_3ck12 = 0 time = 650
.meas tran vdout0_3ck12 FIND v(dout0_3) AT=650.25n

* CHECK dout0_4 Vdout0_4ck12 = 1.8 time = 650
.meas tran vdout0_4ck12 FIND v(dout0_4) AT=650.25n

* CHECK dout0_5 Vdout0_5ck12 = 0 time = 650
.meas tran vdout0_5ck12 FIND v(dout0_5) AT=650.25n

* CHECK dout0_6 Vdout0_6ck12 = 0 time = 650
.meas tran vdout0_6ck12 FIND v(dout0_6) AT=650.25n

* CHECK dout0_7 Vdout0_7ck12 = 1.8 time = 650
.meas tran vdout0_7ck12 FIND v(dout0_7) AT=650.25n

* CHECK dout0_8 Vdout0_8ck12 = 0 time = 650
.meas tran vdout0_8ck12 FIND v(dout0_8) AT=650.25n

* CHECK dout0_9 Vdout0_9ck12 = 0 time = 650
.meas tran vdout0_9ck12 FIND v(dout0_9) AT=650.25n

* CHECK dout0_10 Vdout0_10ck12 = 0 time = 650
.meas tran vdout0_10ck12 FIND v(dout0_10) AT=650.25n

* CHECK dout0_11 Vdout0_11ck12 = 0 time = 650
.meas tran vdout0_11ck12 FIND v(dout0_11) AT=650.25n

* CHECK dout0_12 Vdout0_12ck12 = 1.8 time = 650
.meas tran vdout0_12ck12 FIND v(dout0_12) AT=650.25n

* CHECK dout0_13 Vdout0_13ck12 = 0 time = 650
.meas tran vdout0_13ck12 FIND v(dout0_13) AT=650.25n

* CHECK dout0_14 Vdout0_14ck12 = 0 time = 650
.meas tran vdout0_14ck12 FIND v(dout0_14) AT=650.25n

* CHECK dout0_15 Vdout0_15ck12 = 0 time = 650
.meas tran vdout0_15ck12 FIND v(dout0_15) AT=650.25n

* CHECK dout0_0 Vdout0_0ck15 = 1.8 time = 800
.meas tran vdout0_0ck15 FIND v(dout0_0) AT=800.25n

* CHECK dout0_1 Vdout0_1ck15 = 0 time = 800
.meas tran vdout0_1ck15 FIND v(dout0_1) AT=800.25n

* CHECK dout0_2 Vdout0_2ck15 = 0 time = 800
.meas tran vdout0_2ck15 FIND v(dout0_2) AT=800.25n

* CHECK dout0_3 Vdout0_3ck15 = 1.8 time = 800
.meas tran vdout0_3ck15 FIND v(dout0_3) AT=800.25n

* CHECK dout0_4 Vdout0_4ck15 = 0 time = 800
.meas tran vdout0_4ck15 FIND v(dout0_4) AT=800.25n

* CHECK dout0_5 Vdout0_5ck15 = 0 time = 800
.meas tran vdout0_5ck15 FIND v(dout0_5) AT=800.25n

* CHECK dout0_6 Vdout0_6ck15 = 0 time = 800
.meas tran vdout0_6ck15 FIND v(dout0_6) AT=800.25n

* CHECK dout0_7 Vdout0_7ck15 = 1.8 time = 800
.meas tran vdout0_7ck15 FIND v(dout0_7) AT=800.25n

* CHECK dout0_8 Vdout0_8ck15 = 0 time = 800
.meas tran vdout0_8ck15 FIND v(dout0_8) AT=800.25n

* CHECK dout0_9 Vdout0_9ck15 = 0 time = 800
.meas tran vdout0_9ck15 FIND v(dout0_9) AT=800.25n

* CHECK dout0_10 Vdout0_10ck15 = 0 time = 800
.meas tran vdout0_10ck15 FIND v(dout0_10) AT=800.25n

* CHECK dout0_11 Vdout0_11ck15 = 1.8 time = 800
.meas tran vdout0_11ck15 FIND v(dout0_11) AT=800.25n

* CHECK dout0_12 Vdout0_12ck15 = 1.8 time = 800
.meas tran vdout0_12ck15 FIND v(dout0_12) AT=800.25n

* CHECK dout0_13 Vdout0_13ck15 = 1.8 time = 800
.meas tran vdout0_13ck15 FIND v(dout0_13) AT=800.25n

* CHECK dout0_14 Vdout0_14ck15 = 0 time = 800
.meas tran vdout0_14ck15 FIND v(dout0_14) AT=800.25n

* CHECK dout0_15 Vdout0_15ck15 = 0 time = 800
.meas tran vdout0_15ck15 FIND v(dout0_15) AT=800.25n

* CHECK dout0_0 Vdout0_0ck17 = 0 time = 900
.meas tran vdout0_0ck17 FIND v(dout0_0) AT=900.25n

* CHECK dout0_1 Vdout0_1ck17 = 0 time = 900
.meas tran vdout0_1ck17 FIND v(dout0_1) AT=900.25n

* CHECK dout0_2 Vdout0_2ck17 = 0 time = 900
.meas tran vdout0_2ck17 FIND v(dout0_2) AT=900.25n

* CHECK dout0_3 Vdout0_3ck17 = 1.8 time = 900
.meas tran vdout0_3ck17 FIND v(dout0_3) AT=900.25n

* CHECK dout0_4 Vdout0_4ck17 = 0 time = 900
.meas tran vdout0_4ck17 FIND v(dout0_4) AT=900.25n

* CHECK dout0_5 Vdout0_5ck17 = 1.8 time = 900
.meas tran vdout0_5ck17 FIND v(dout0_5) AT=900.25n

* CHECK dout0_6 Vdout0_6ck17 = 1.8 time = 900
.meas tran vdout0_6ck17 FIND v(dout0_6) AT=900.25n

* CHECK dout0_7 Vdout0_7ck17 = 1.8 time = 900
.meas tran vdout0_7ck17 FIND v(dout0_7) AT=900.25n

* CHECK dout0_8 Vdout0_8ck17 = 1.8 time = 900
.meas tran vdout0_8ck17 FIND v(dout0_8) AT=900.25n

* CHECK dout0_9 Vdout0_9ck17 = 0 time = 900
.meas tran vdout0_9ck17 FIND v(dout0_9) AT=900.25n

* CHECK dout0_10 Vdout0_10ck17 = 1.8 time = 900
.meas tran vdout0_10ck17 FIND v(dout0_10) AT=900.25n

* CHECK dout0_11 Vdout0_11ck17 = 1.8 time = 900
.meas tran vdout0_11ck17 FIND v(dout0_11) AT=900.25n

* CHECK dout0_12 Vdout0_12ck17 = 0 time = 900
.meas tran vdout0_12ck17 FIND v(dout0_12) AT=900.25n

* CHECK dout0_13 Vdout0_13ck17 = 1.8 time = 900
.meas tran vdout0_13ck17 FIND v(dout0_13) AT=900.25n

* CHECK dout0_14 Vdout0_14ck17 = 1.8 time = 900
.meas tran vdout0_14ck17 FIND v(dout0_14) AT=900.25n

* CHECK dout0_15 Vdout0_15ck17 = 0 time = 900
.meas tran vdout0_15ck17 FIND v(dout0_15) AT=900.25n

* CHECK dout0_0 Vdout0_0ck18 = 1.8 time = 950
.meas tran vdout0_0ck18 FIND v(dout0_0) AT=950.25n

* CHECK dout0_1 Vdout0_1ck18 = 0 time = 950
.meas tran vdout0_1ck18 FIND v(dout0_1) AT=950.25n

* CHECK dout0_2 Vdout0_2ck18 = 1.8 time = 950
.meas tran vdout0_2ck18 FIND v(dout0_2) AT=950.25n

* CHECK dout0_3 Vdout0_3ck18 = 0 time = 950
.meas tran vdout0_3ck18 FIND v(dout0_3) AT=950.25n

* CHECK dout0_4 Vdout0_4ck18 = 0 time = 950
.meas tran vdout0_4ck18 FIND v(dout0_4) AT=950.25n

* CHECK dout0_5 Vdout0_5ck18 = 0 time = 950
.meas tran vdout0_5ck18 FIND v(dout0_5) AT=950.25n

* CHECK dout0_6 Vdout0_6ck18 = 1.8 time = 950
.meas tran vdout0_6ck18 FIND v(dout0_6) AT=950.25n

* CHECK dout0_7 Vdout0_7ck18 = 0 time = 950
.meas tran vdout0_7ck18 FIND v(dout0_7) AT=950.25n

* CHECK dout0_8 Vdout0_8ck18 = 0 time = 950
.meas tran vdout0_8ck18 FIND v(dout0_8) AT=950.25n

* CHECK dout0_9 Vdout0_9ck18 = 0 time = 950
.meas tran vdout0_9ck18 FIND v(dout0_9) AT=950.25n

* CHECK dout0_10 Vdout0_10ck18 = 1.8 time = 950
.meas tran vdout0_10ck18 FIND v(dout0_10) AT=950.25n

* CHECK dout0_11 Vdout0_11ck18 = 0 time = 950
.meas tran vdout0_11ck18 FIND v(dout0_11) AT=950.25n

* CHECK dout0_12 Vdout0_12ck18 = 0 time = 950
.meas tran vdout0_12ck18 FIND v(dout0_12) AT=950.25n

* CHECK dout0_13 Vdout0_13ck18 = 0 time = 950
.meas tran vdout0_13ck18 FIND v(dout0_13) AT=950.25n

* CHECK dout0_14 Vdout0_14ck18 = 0 time = 950
.meas tran vdout0_14ck18 FIND v(dout0_14) AT=950.25n

* CHECK dout0_15 Vdout0_15ck18 = 0 time = 950
.meas tran vdout0_15ck18 FIND v(dout0_15) AT=950.25n

* CHECK dout0_0 Vdout0_0ck19 = 0 time = 1000
.meas tran vdout0_0ck19 FIND v(dout0_0) AT=1000.25n

* CHECK dout0_1 Vdout0_1ck19 = 0 time = 1000
.meas tran vdout0_1ck19 FIND v(dout0_1) AT=1000.25n

* CHECK dout0_2 Vdout0_2ck19 = 1.8 time = 1000
.meas tran vdout0_2ck19 FIND v(dout0_2) AT=1000.25n

* CHECK dout0_3 Vdout0_3ck19 = 1.8 time = 1000
.meas tran vdout0_3ck19 FIND v(dout0_3) AT=1000.25n

* CHECK dout0_4 Vdout0_4ck19 = 0 time = 1000
.meas tran vdout0_4ck19 FIND v(dout0_4) AT=1000.25n

* CHECK dout0_5 Vdout0_5ck19 = 0 time = 1000
.meas tran vdout0_5ck19 FIND v(dout0_5) AT=1000.25n

* CHECK dout0_6 Vdout0_6ck19 = 1.8 time = 1000
.meas tran vdout0_6ck19 FIND v(dout0_6) AT=1000.25n

* CHECK dout0_7 Vdout0_7ck19 = 1.8 time = 1000
.meas tran vdout0_7ck19 FIND v(dout0_7) AT=1000.25n

* CHECK dout0_8 Vdout0_8ck19 = 0 time = 1000
.meas tran vdout0_8ck19 FIND v(dout0_8) AT=1000.25n

* CHECK dout0_9 Vdout0_9ck19 = 1.8 time = 1000
.meas tran vdout0_9ck19 FIND v(dout0_9) AT=1000.25n

* CHECK dout0_10 Vdout0_10ck19 = 0 time = 1000
.meas tran vdout0_10ck19 FIND v(dout0_10) AT=1000.25n

* CHECK dout0_11 Vdout0_11ck19 = 0 time = 1000
.meas tran vdout0_11ck19 FIND v(dout0_11) AT=1000.25n

* CHECK dout0_12 Vdout0_12ck19 = 1.8 time = 1000
.meas tran vdout0_12ck19 FIND v(dout0_12) AT=1000.25n

* CHECK dout0_13 Vdout0_13ck19 = 0 time = 1000
.meas tran vdout0_13ck19 FIND v(dout0_13) AT=1000.25n

* CHECK dout0_14 Vdout0_14ck19 = 1.8 time = 1000
.meas tran vdout0_14ck19 FIND v(dout0_14) AT=1000.25n

* CHECK dout0_15 Vdout0_15ck19 = 1.8 time = 1000
.meas tran vdout0_15ck19 FIND v(dout0_15) AT=1000.25n

* CHECK dout0_0 Vdout0_0ck25 = 1.8 time = 1300
.meas tran vdout0_0ck25 FIND v(dout0_0) AT=1300.25n

* CHECK dout0_1 Vdout0_1ck25 = 0 time = 1300
.meas tran vdout0_1ck25 FIND v(dout0_1) AT=1300.25n

* CHECK dout0_2 Vdout0_2ck25 = 0 time = 1300
.meas tran vdout0_2ck25 FIND v(dout0_2) AT=1300.25n

* CHECK dout0_3 Vdout0_3ck25 = 0 time = 1300
.meas tran vdout0_3ck25 FIND v(dout0_3) AT=1300.25n

* CHECK dout0_4 Vdout0_4ck25 = 1.8 time = 1300
.meas tran vdout0_4ck25 FIND v(dout0_4) AT=1300.25n

* CHECK dout0_5 Vdout0_5ck25 = 0 time = 1300
.meas tran vdout0_5ck25 FIND v(dout0_5) AT=1300.25n

* CHECK dout0_6 Vdout0_6ck25 = 1.8 time = 1300
.meas tran vdout0_6ck25 FIND v(dout0_6) AT=1300.25n

* CHECK dout0_7 Vdout0_7ck25 = 1.8 time = 1300
.meas tran vdout0_7ck25 FIND v(dout0_7) AT=1300.25n

* CHECK dout0_8 Vdout0_8ck25 = 1.8 time = 1300
.meas tran vdout0_8ck25 FIND v(dout0_8) AT=1300.25n

* CHECK dout0_9 Vdout0_9ck25 = 1.8 time = 1300
.meas tran vdout0_9ck25 FIND v(dout0_9) AT=1300.25n

* CHECK dout0_10 Vdout0_10ck25 = 1.8 time = 1300
.meas tran vdout0_10ck25 FIND v(dout0_10) AT=1300.25n

* CHECK dout0_11 Vdout0_11ck25 = 1.8 time = 1300
.meas tran vdout0_11ck25 FIND v(dout0_11) AT=1300.25n

* CHECK dout0_12 Vdout0_12ck25 = 0 time = 1300
.meas tran vdout0_12ck25 FIND v(dout0_12) AT=1300.25n

* CHECK dout0_13 Vdout0_13ck25 = 1.8 time = 1300
.meas tran vdout0_13ck25 FIND v(dout0_13) AT=1300.25n

* CHECK dout0_14 Vdout0_14ck25 = 0 time = 1300
.meas tran vdout0_14ck25 FIND v(dout0_14) AT=1300.25n

* CHECK dout0_15 Vdout0_15ck25 = 0 time = 1300
.meas tran vdout0_15ck25 FIND v(dout0_15) AT=1300.25n

* CHECK dout0_0 Vdout0_0ck26 = 0 time = 1350
.meas tran vdout0_0ck26 FIND v(dout0_0) AT=1350.25n

* CHECK dout0_1 Vdout0_1ck26 = 0 time = 1350
.meas tran vdout0_1ck26 FIND v(dout0_1) AT=1350.25n

* CHECK dout0_2 Vdout0_2ck26 = 0 time = 1350
.meas tran vdout0_2ck26 FIND v(dout0_2) AT=1350.25n

* CHECK dout0_3 Vdout0_3ck26 = 1.8 time = 1350
.meas tran vdout0_3ck26 FIND v(dout0_3) AT=1350.25n

* CHECK dout0_4 Vdout0_4ck26 = 0 time = 1350
.meas tran vdout0_4ck26 FIND v(dout0_4) AT=1350.25n

* CHECK dout0_5 Vdout0_5ck26 = 1.8 time = 1350
.meas tran vdout0_5ck26 FIND v(dout0_5) AT=1350.25n

* CHECK dout0_6 Vdout0_6ck26 = 1.8 time = 1350
.meas tran vdout0_6ck26 FIND v(dout0_6) AT=1350.25n

* CHECK dout0_7 Vdout0_7ck26 = 1.8 time = 1350
.meas tran vdout0_7ck26 FIND v(dout0_7) AT=1350.25n

* CHECK dout0_8 Vdout0_8ck26 = 1.8 time = 1350
.meas tran vdout0_8ck26 FIND v(dout0_8) AT=1350.25n

* CHECK dout0_9 Vdout0_9ck26 = 0 time = 1350
.meas tran vdout0_9ck26 FIND v(dout0_9) AT=1350.25n

* CHECK dout0_10 Vdout0_10ck26 = 1.8 time = 1350
.meas tran vdout0_10ck26 FIND v(dout0_10) AT=1350.25n

* CHECK dout0_11 Vdout0_11ck26 = 1.8 time = 1350
.meas tran vdout0_11ck26 FIND v(dout0_11) AT=1350.25n

* CHECK dout0_12 Vdout0_12ck26 = 0 time = 1350
.meas tran vdout0_12ck26 FIND v(dout0_12) AT=1350.25n

* CHECK dout0_13 Vdout0_13ck26 = 1.8 time = 1350
.meas tran vdout0_13ck26 FIND v(dout0_13) AT=1350.25n

* CHECK dout0_14 Vdout0_14ck26 = 1.8 time = 1350
.meas tran vdout0_14ck26 FIND v(dout0_14) AT=1350.25n

* CHECK dout0_15 Vdout0_15ck26 = 0 time = 1350
.meas tran vdout0_15ck26 FIND v(dout0_15) AT=1350.25n

* CHECK dout0_0 Vdout0_0ck27 = 0 time = 1400
.meas tran vdout0_0ck27 FIND v(dout0_0) AT=1400.25n

* CHECK dout0_1 Vdout0_1ck27 = 0 time = 1400
.meas tran vdout0_1ck27 FIND v(dout0_1) AT=1400.25n

* CHECK dout0_2 Vdout0_2ck27 = 0 time = 1400
.meas tran vdout0_2ck27 FIND v(dout0_2) AT=1400.25n

* CHECK dout0_3 Vdout0_3ck27 = 0 time = 1400
.meas tran vdout0_3ck27 FIND v(dout0_3) AT=1400.25n

* CHECK dout0_4 Vdout0_4ck27 = 0 time = 1400
.meas tran vdout0_4ck27 FIND v(dout0_4) AT=1400.25n

* CHECK dout0_5 Vdout0_5ck27 = 1.8 time = 1400
.meas tran vdout0_5ck27 FIND v(dout0_5) AT=1400.25n

* CHECK dout0_6 Vdout0_6ck27 = 0 time = 1400
.meas tran vdout0_6ck27 FIND v(dout0_6) AT=1400.25n

* CHECK dout0_7 Vdout0_7ck27 = 1.8 time = 1400
.meas tran vdout0_7ck27 FIND v(dout0_7) AT=1400.25n

* CHECK dout0_8 Vdout0_8ck27 = 0 time = 1400
.meas tran vdout0_8ck27 FIND v(dout0_8) AT=1400.25n

* CHECK dout0_9 Vdout0_9ck27 = 1.8 time = 1400
.meas tran vdout0_9ck27 FIND v(dout0_9) AT=1400.25n

* CHECK dout0_10 Vdout0_10ck27 = 1.8 time = 1400
.meas tran vdout0_10ck27 FIND v(dout0_10) AT=1400.25n

* CHECK dout0_11 Vdout0_11ck27 = 0 time = 1400
.meas tran vdout0_11ck27 FIND v(dout0_11) AT=1400.25n

* CHECK dout0_12 Vdout0_12ck27 = 0 time = 1400
.meas tran vdout0_12ck27 FIND v(dout0_12) AT=1400.25n

* CHECK dout0_13 Vdout0_13ck27 = 1.8 time = 1400
.meas tran vdout0_13ck27 FIND v(dout0_13) AT=1400.25n

* CHECK dout0_14 Vdout0_14ck27 = 1.8 time = 1400
.meas tran vdout0_14ck27 FIND v(dout0_14) AT=1400.25n

* CHECK dout0_15 Vdout0_15ck27 = 0 time = 1400
.meas tran vdout0_15ck27 FIND v(dout0_15) AT=1400.25n

* CHECK dout0_0 Vdout0_0ck29 = 0 time = 1500
.meas tran vdout0_0ck29 FIND v(dout0_0) AT=1500.25n

* CHECK dout0_1 Vdout0_1ck29 = 0 time = 1500
.meas tran vdout0_1ck29 FIND v(dout0_1) AT=1500.25n

* CHECK dout0_2 Vdout0_2ck29 = 1.8 time = 1500
.meas tran vdout0_2ck29 FIND v(dout0_2) AT=1500.25n

* CHECK dout0_3 Vdout0_3ck29 = 1.8 time = 1500
.meas tran vdout0_3ck29 FIND v(dout0_3) AT=1500.25n

* CHECK dout0_4 Vdout0_4ck29 = 0 time = 1500
.meas tran vdout0_4ck29 FIND v(dout0_4) AT=1500.25n

* CHECK dout0_5 Vdout0_5ck29 = 0 time = 1500
.meas tran vdout0_5ck29 FIND v(dout0_5) AT=1500.25n

* CHECK dout0_6 Vdout0_6ck29 = 1.8 time = 1500
.meas tran vdout0_6ck29 FIND v(dout0_6) AT=1500.25n

* CHECK dout0_7 Vdout0_7ck29 = 1.8 time = 1500
.meas tran vdout0_7ck29 FIND v(dout0_7) AT=1500.25n

* CHECK dout0_8 Vdout0_8ck29 = 0 time = 1500
.meas tran vdout0_8ck29 FIND v(dout0_8) AT=1500.25n

* CHECK dout0_9 Vdout0_9ck29 = 1.8 time = 1500
.meas tran vdout0_9ck29 FIND v(dout0_9) AT=1500.25n

* CHECK dout0_10 Vdout0_10ck29 = 0 time = 1500
.meas tran vdout0_10ck29 FIND v(dout0_10) AT=1500.25n

* CHECK dout0_11 Vdout0_11ck29 = 0 time = 1500
.meas tran vdout0_11ck29 FIND v(dout0_11) AT=1500.25n

* CHECK dout0_12 Vdout0_12ck29 = 1.8 time = 1500
.meas tran vdout0_12ck29 FIND v(dout0_12) AT=1500.25n

* CHECK dout0_13 Vdout0_13ck29 = 0 time = 1500
.meas tran vdout0_13ck29 FIND v(dout0_13) AT=1500.25n

* CHECK dout0_14 Vdout0_14ck29 = 1.8 time = 1500
.meas tran vdout0_14ck29 FIND v(dout0_14) AT=1500.25n

* CHECK dout0_15 Vdout0_15ck29 = 1.8 time = 1500
.meas tran vdout0_15ck29 FIND v(dout0_15) AT=1500.25n

* CHECK dout0_0 Vdout0_0ck31 = 0 time = 1600
.meas tran vdout0_0ck31 FIND v(dout0_0) AT=1600.25n

* CHECK dout0_1 Vdout0_1ck31 = 0 time = 1600
.meas tran vdout0_1ck31 FIND v(dout0_1) AT=1600.25n

* CHECK dout0_2 Vdout0_2ck31 = 0 time = 1600
.meas tran vdout0_2ck31 FIND v(dout0_2) AT=1600.25n

* CHECK dout0_3 Vdout0_3ck31 = 0 time = 1600
.meas tran vdout0_3ck31 FIND v(dout0_3) AT=1600.25n

* CHECK dout0_4 Vdout0_4ck31 = 1.8 time = 1600
.meas tran vdout0_4ck31 FIND v(dout0_4) AT=1600.25n

* CHECK dout0_5 Vdout0_5ck31 = 0 time = 1600
.meas tran vdout0_5ck31 FIND v(dout0_5) AT=1600.25n

* CHECK dout0_6 Vdout0_6ck31 = 0 time = 1600
.meas tran vdout0_6ck31 FIND v(dout0_6) AT=1600.25n

* CHECK dout0_7 Vdout0_7ck31 = 1.8 time = 1600
.meas tran vdout0_7ck31 FIND v(dout0_7) AT=1600.25n

* CHECK dout0_8 Vdout0_8ck31 = 0 time = 1600
.meas tran vdout0_8ck31 FIND v(dout0_8) AT=1600.25n

* CHECK dout0_9 Vdout0_9ck31 = 0 time = 1600
.meas tran vdout0_9ck31 FIND v(dout0_9) AT=1600.25n

* CHECK dout0_10 Vdout0_10ck31 = 0 time = 1600
.meas tran vdout0_10ck31 FIND v(dout0_10) AT=1600.25n

* CHECK dout0_11 Vdout0_11ck31 = 0 time = 1600
.meas tran vdout0_11ck31 FIND v(dout0_11) AT=1600.25n

* CHECK dout0_12 Vdout0_12ck31 = 1.8 time = 1600
.meas tran vdout0_12ck31 FIND v(dout0_12) AT=1600.25n

* CHECK dout0_13 Vdout0_13ck31 = 0 time = 1600
.meas tran vdout0_13ck31 FIND v(dout0_13) AT=1600.25n

* CHECK dout0_14 Vdout0_14ck31 = 0 time = 1600
.meas tran vdout0_14ck31 FIND v(dout0_14) AT=1600.25n

* CHECK dout0_15 Vdout0_15ck31 = 0 time = 1600
.meas tran vdout0_15ck31 FIND v(dout0_15) AT=1600.25n

* CHECK dout0_0 Vdout0_0ck33 = 0 time = 1700
.meas tran vdout0_0ck33 FIND v(dout0_0) AT=1700.25n

* CHECK dout0_1 Vdout0_1ck33 = 0 time = 1700
.meas tran vdout0_1ck33 FIND v(dout0_1) AT=1700.25n

* CHECK dout0_2 Vdout0_2ck33 = 0 time = 1700
.meas tran vdout0_2ck33 FIND v(dout0_2) AT=1700.25n

* CHECK dout0_3 Vdout0_3ck33 = 0 time = 1700
.meas tran vdout0_3ck33 FIND v(dout0_3) AT=1700.25n

* CHECK dout0_4 Vdout0_4ck33 = 0 time = 1700
.meas tran vdout0_4ck33 FIND v(dout0_4) AT=1700.25n

* CHECK dout0_5 Vdout0_5ck33 = 1.8 time = 1700
.meas tran vdout0_5ck33 FIND v(dout0_5) AT=1700.25n

* CHECK dout0_6 Vdout0_6ck33 = 0 time = 1700
.meas tran vdout0_6ck33 FIND v(dout0_6) AT=1700.25n

* CHECK dout0_7 Vdout0_7ck33 = 1.8 time = 1700
.meas tran vdout0_7ck33 FIND v(dout0_7) AT=1700.25n

* CHECK dout0_8 Vdout0_8ck33 = 0 time = 1700
.meas tran vdout0_8ck33 FIND v(dout0_8) AT=1700.25n

* CHECK dout0_9 Vdout0_9ck33 = 1.8 time = 1700
.meas tran vdout0_9ck33 FIND v(dout0_9) AT=1700.25n

* CHECK dout0_10 Vdout0_10ck33 = 1.8 time = 1700
.meas tran vdout0_10ck33 FIND v(dout0_10) AT=1700.25n

* CHECK dout0_11 Vdout0_11ck33 = 0 time = 1700
.meas tran vdout0_11ck33 FIND v(dout0_11) AT=1700.25n

* CHECK dout0_12 Vdout0_12ck33 = 0 time = 1700
.meas tran vdout0_12ck33 FIND v(dout0_12) AT=1700.25n

* CHECK dout0_13 Vdout0_13ck33 = 1.8 time = 1700
.meas tran vdout0_13ck33 FIND v(dout0_13) AT=1700.25n

* CHECK dout0_14 Vdout0_14ck33 = 1.8 time = 1700
.meas tran vdout0_14ck33 FIND v(dout0_14) AT=1700.25n

* CHECK dout0_15 Vdout0_15ck33 = 0 time = 1700
.meas tran vdout0_15ck33 FIND v(dout0_15) AT=1700.25n

* CHECK dout0_0 Vdout0_0ck34 = 1.8 time = 1750
.meas tran vdout0_0ck34 FIND v(dout0_0) AT=1750.25n

* CHECK dout0_1 Vdout0_1ck34 = 0 time = 1750
.meas tran vdout0_1ck34 FIND v(dout0_1) AT=1750.25n

* CHECK dout0_2 Vdout0_2ck34 = 0 time = 1750
.meas tran vdout0_2ck34 FIND v(dout0_2) AT=1750.25n

* CHECK dout0_3 Vdout0_3ck34 = 1.8 time = 1750
.meas tran vdout0_3ck34 FIND v(dout0_3) AT=1750.25n

* CHECK dout0_4 Vdout0_4ck34 = 1.8 time = 1750
.meas tran vdout0_4ck34 FIND v(dout0_4) AT=1750.25n

* CHECK dout0_5 Vdout0_5ck34 = 1.8 time = 1750
.meas tran vdout0_5ck34 FIND v(dout0_5) AT=1750.25n

* CHECK dout0_6 Vdout0_6ck34 = 1.8 time = 1750
.meas tran vdout0_6ck34 FIND v(dout0_6) AT=1750.25n

* CHECK dout0_7 Vdout0_7ck34 = 0 time = 1750
.meas tran vdout0_7ck34 FIND v(dout0_7) AT=1750.25n

* CHECK dout0_8 Vdout0_8ck34 = 1.8 time = 1750
.meas tran vdout0_8ck34 FIND v(dout0_8) AT=1750.25n

* CHECK dout0_9 Vdout0_9ck34 = 1.8 time = 1750
.meas tran vdout0_9ck34 FIND v(dout0_9) AT=1750.25n

* CHECK dout0_10 Vdout0_10ck34 = 1.8 time = 1750
.meas tran vdout0_10ck34 FIND v(dout0_10) AT=1750.25n

* CHECK dout0_11 Vdout0_11ck34 = 1.8 time = 1750
.meas tran vdout0_11ck34 FIND v(dout0_11) AT=1750.25n

* CHECK dout0_12 Vdout0_12ck34 = 1.8 time = 1750
.meas tran vdout0_12ck34 FIND v(dout0_12) AT=1750.25n

* CHECK dout0_13 Vdout0_13ck34 = 1.8 time = 1750
.meas tran vdout0_13ck34 FIND v(dout0_13) AT=1750.25n

* CHECK dout0_14 Vdout0_14ck34 = 1.8 time = 1750
.meas tran vdout0_14ck34 FIND v(dout0_14) AT=1750.25n

* CHECK dout0_15 Vdout0_15ck34 = 1.8 time = 1750
.meas tran vdout0_15ck34 FIND v(dout0_15) AT=1750.25n

* CHECK dout0_0 Vdout0_0ck35 = 0 time = 1800
.meas tran vdout0_0ck35 FIND v(dout0_0) AT=1800.25n

* CHECK dout0_1 Vdout0_1ck35 = 0 time = 1800
.meas tran vdout0_1ck35 FIND v(dout0_1) AT=1800.25n

* CHECK dout0_2 Vdout0_2ck35 = 0 time = 1800
.meas tran vdout0_2ck35 FIND v(dout0_2) AT=1800.25n

* CHECK dout0_3 Vdout0_3ck35 = 1.8 time = 1800
.meas tran vdout0_3ck35 FIND v(dout0_3) AT=1800.25n

* CHECK dout0_4 Vdout0_4ck35 = 0 time = 1800
.meas tran vdout0_4ck35 FIND v(dout0_4) AT=1800.25n

* CHECK dout0_5 Vdout0_5ck35 = 1.8 time = 1800
.meas tran vdout0_5ck35 FIND v(dout0_5) AT=1800.25n

* CHECK dout0_6 Vdout0_6ck35 = 1.8 time = 1800
.meas tran vdout0_6ck35 FIND v(dout0_6) AT=1800.25n

* CHECK dout0_7 Vdout0_7ck35 = 1.8 time = 1800
.meas tran vdout0_7ck35 FIND v(dout0_7) AT=1800.25n

* CHECK dout0_8 Vdout0_8ck35 = 1.8 time = 1800
.meas tran vdout0_8ck35 FIND v(dout0_8) AT=1800.25n

* CHECK dout0_9 Vdout0_9ck35 = 0 time = 1800
.meas tran vdout0_9ck35 FIND v(dout0_9) AT=1800.25n

* CHECK dout0_10 Vdout0_10ck35 = 1.8 time = 1800
.meas tran vdout0_10ck35 FIND v(dout0_10) AT=1800.25n

* CHECK dout0_11 Vdout0_11ck35 = 1.8 time = 1800
.meas tran vdout0_11ck35 FIND v(dout0_11) AT=1800.25n

* CHECK dout0_12 Vdout0_12ck35 = 0 time = 1800
.meas tran vdout0_12ck35 FIND v(dout0_12) AT=1800.25n

* CHECK dout0_13 Vdout0_13ck35 = 1.8 time = 1800
.meas tran vdout0_13ck35 FIND v(dout0_13) AT=1800.25n

* CHECK dout0_14 Vdout0_14ck35 = 1.8 time = 1800
.meas tran vdout0_14ck35 FIND v(dout0_14) AT=1800.25n

* CHECK dout0_15 Vdout0_15ck35 = 0 time = 1800
.meas tran vdout0_15ck35 FIND v(dout0_15) AT=1800.25n

* CHECK dout0_0 Vdout0_0ck40 = 0 time = 2050
.meas tran vdout0_0ck40 FIND v(dout0_0) AT=2050.25n

* CHECK dout0_1 Vdout0_1ck40 = 0 time = 2050
.meas tran vdout0_1ck40 FIND v(dout0_1) AT=2050.25n

* CHECK dout0_2 Vdout0_2ck40 = 0 time = 2050
.meas tran vdout0_2ck40 FIND v(dout0_2) AT=2050.25n

* CHECK dout0_3 Vdout0_3ck40 = 0 time = 2050
.meas tran vdout0_3ck40 FIND v(dout0_3) AT=2050.25n

* CHECK dout0_4 Vdout0_4ck40 = 0 time = 2050
.meas tran vdout0_4ck40 FIND v(dout0_4) AT=2050.25n

* CHECK dout0_5 Vdout0_5ck40 = 1.8 time = 2050
.meas tran vdout0_5ck40 FIND v(dout0_5) AT=2050.25n

* CHECK dout0_6 Vdout0_6ck40 = 0 time = 2050
.meas tran vdout0_6ck40 FIND v(dout0_6) AT=2050.25n

* CHECK dout0_7 Vdout0_7ck40 = 1.8 time = 2050
.meas tran vdout0_7ck40 FIND v(dout0_7) AT=2050.25n

* CHECK dout0_8 Vdout0_8ck40 = 0 time = 2050
.meas tran vdout0_8ck40 FIND v(dout0_8) AT=2050.25n

* CHECK dout0_9 Vdout0_9ck40 = 1.8 time = 2050
.meas tran vdout0_9ck40 FIND v(dout0_9) AT=2050.25n

* CHECK dout0_10 Vdout0_10ck40 = 1.8 time = 2050
.meas tran vdout0_10ck40 FIND v(dout0_10) AT=2050.25n

* CHECK dout0_11 Vdout0_11ck40 = 0 time = 2050
.meas tran vdout0_11ck40 FIND v(dout0_11) AT=2050.25n

* CHECK dout0_12 Vdout0_12ck40 = 0 time = 2050
.meas tran vdout0_12ck40 FIND v(dout0_12) AT=2050.25n

* CHECK dout0_13 Vdout0_13ck40 = 1.8 time = 2050
.meas tran vdout0_13ck40 FIND v(dout0_13) AT=2050.25n

* CHECK dout0_14 Vdout0_14ck40 = 1.8 time = 2050
.meas tran vdout0_14ck40 FIND v(dout0_14) AT=2050.25n

* CHECK dout0_15 Vdout0_15ck40 = 0 time = 2050
.meas tran vdout0_15ck40 FIND v(dout0_15) AT=2050.25n

* CHECK dout0_0 Vdout0_0ck41 = 0 time = 2100
.meas tran vdout0_0ck41 FIND v(dout0_0) AT=2100.25n

* CHECK dout0_1 Vdout0_1ck41 = 0 time = 2100
.meas tran vdout0_1ck41 FIND v(dout0_1) AT=2100.25n

* CHECK dout0_2 Vdout0_2ck41 = 1.8 time = 2100
.meas tran vdout0_2ck41 FIND v(dout0_2) AT=2100.25n

* CHECK dout0_3 Vdout0_3ck41 = 0 time = 2100
.meas tran vdout0_3ck41 FIND v(dout0_3) AT=2100.25n

* CHECK dout0_4 Vdout0_4ck41 = 1.8 time = 2100
.meas tran vdout0_4ck41 FIND v(dout0_4) AT=2100.25n

* CHECK dout0_5 Vdout0_5ck41 = 1.8 time = 2100
.meas tran vdout0_5ck41 FIND v(dout0_5) AT=2100.25n

* CHECK dout0_6 Vdout0_6ck41 = 1.8 time = 2100
.meas tran vdout0_6ck41 FIND v(dout0_6) AT=2100.25n

* CHECK dout0_7 Vdout0_7ck41 = 1.8 time = 2100
.meas tran vdout0_7ck41 FIND v(dout0_7) AT=2100.25n

* CHECK dout0_8 Vdout0_8ck41 = 0 time = 2100
.meas tran vdout0_8ck41 FIND v(dout0_8) AT=2100.25n

* CHECK dout0_9 Vdout0_9ck41 = 0 time = 2100
.meas tran vdout0_9ck41 FIND v(dout0_9) AT=2100.25n

* CHECK dout0_10 Vdout0_10ck41 = 0 time = 2100
.meas tran vdout0_10ck41 FIND v(dout0_10) AT=2100.25n

* CHECK dout0_11 Vdout0_11ck41 = 0 time = 2100
.meas tran vdout0_11ck41 FIND v(dout0_11) AT=2100.25n

* CHECK dout0_12 Vdout0_12ck41 = 1.8 time = 2100
.meas tran vdout0_12ck41 FIND v(dout0_12) AT=2100.25n

* CHECK dout0_13 Vdout0_13ck41 = 0 time = 2100
.meas tran vdout0_13ck41 FIND v(dout0_13) AT=2100.25n

* CHECK dout0_14 Vdout0_14ck41 = 1.8 time = 2100
.meas tran vdout0_14ck41 FIND v(dout0_14) AT=2100.25n

* CHECK dout0_15 Vdout0_15ck41 = 1.8 time = 2100
.meas tran vdout0_15ck41 FIND v(dout0_15) AT=2100.25n

* CHECK dout0_0 Vdout0_0ck42 = 0 time = 2150
.meas tran vdout0_0ck42 FIND v(dout0_0) AT=2150.25n

* CHECK dout0_1 Vdout0_1ck42 = 0 time = 2150
.meas tran vdout0_1ck42 FIND v(dout0_1) AT=2150.25n

* CHECK dout0_2 Vdout0_2ck42 = 0 time = 2150
.meas tran vdout0_2ck42 FIND v(dout0_2) AT=2150.25n

* CHECK dout0_3 Vdout0_3ck42 = 0 time = 2150
.meas tran vdout0_3ck42 FIND v(dout0_3) AT=2150.25n

* CHECK dout0_4 Vdout0_4ck42 = 1.8 time = 2150
.meas tran vdout0_4ck42 FIND v(dout0_4) AT=2150.25n

* CHECK dout0_5 Vdout0_5ck42 = 0 time = 2150
.meas tran vdout0_5ck42 FIND v(dout0_5) AT=2150.25n

* CHECK dout0_6 Vdout0_6ck42 = 0 time = 2150
.meas tran vdout0_6ck42 FIND v(dout0_6) AT=2150.25n

* CHECK dout0_7 Vdout0_7ck42 = 1.8 time = 2150
.meas tran vdout0_7ck42 FIND v(dout0_7) AT=2150.25n

* CHECK dout0_8 Vdout0_8ck42 = 0 time = 2150
.meas tran vdout0_8ck42 FIND v(dout0_8) AT=2150.25n

* CHECK dout0_9 Vdout0_9ck42 = 0 time = 2150
.meas tran vdout0_9ck42 FIND v(dout0_9) AT=2150.25n

* CHECK dout0_10 Vdout0_10ck42 = 0 time = 2150
.meas tran vdout0_10ck42 FIND v(dout0_10) AT=2150.25n

* CHECK dout0_11 Vdout0_11ck42 = 0 time = 2150
.meas tran vdout0_11ck42 FIND v(dout0_11) AT=2150.25n

* CHECK dout0_12 Vdout0_12ck42 = 1.8 time = 2150
.meas tran vdout0_12ck42 FIND v(dout0_12) AT=2150.25n

* CHECK dout0_13 Vdout0_13ck42 = 0 time = 2150
.meas tran vdout0_13ck42 FIND v(dout0_13) AT=2150.25n

* CHECK dout0_14 Vdout0_14ck42 = 0 time = 2150
.meas tran vdout0_14ck42 FIND v(dout0_14) AT=2150.25n

* CHECK dout0_15 Vdout0_15ck42 = 0 time = 2150
.meas tran vdout0_15ck42 FIND v(dout0_15) AT=2150.25n

* CHECK dout0_0 Vdout0_0ck43 = 0 time = 2200
.meas tran vdout0_0ck43 FIND v(dout0_0) AT=2200.25n

* CHECK dout0_1 Vdout0_1ck43 = 0 time = 2200
.meas tran vdout0_1ck43 FIND v(dout0_1) AT=2200.25n

* CHECK dout0_2 Vdout0_2ck43 = 0 time = 2200
.meas tran vdout0_2ck43 FIND v(dout0_2) AT=2200.25n

* CHECK dout0_3 Vdout0_3ck43 = 0 time = 2200
.meas tran vdout0_3ck43 FIND v(dout0_3) AT=2200.25n

* CHECK dout0_4 Vdout0_4ck43 = 0 time = 2200
.meas tran vdout0_4ck43 FIND v(dout0_4) AT=2200.25n

* CHECK dout0_5 Vdout0_5ck43 = 1.8 time = 2200
.meas tran vdout0_5ck43 FIND v(dout0_5) AT=2200.25n

* CHECK dout0_6 Vdout0_6ck43 = 0 time = 2200
.meas tran vdout0_6ck43 FIND v(dout0_6) AT=2200.25n

* CHECK dout0_7 Vdout0_7ck43 = 1.8 time = 2200
.meas tran vdout0_7ck43 FIND v(dout0_7) AT=2200.25n

* CHECK dout0_8 Vdout0_8ck43 = 0 time = 2200
.meas tran vdout0_8ck43 FIND v(dout0_8) AT=2200.25n

* CHECK dout0_9 Vdout0_9ck43 = 1.8 time = 2200
.meas tran vdout0_9ck43 FIND v(dout0_9) AT=2200.25n

* CHECK dout0_10 Vdout0_10ck43 = 1.8 time = 2200
.meas tran vdout0_10ck43 FIND v(dout0_10) AT=2200.25n

* CHECK dout0_11 Vdout0_11ck43 = 0 time = 2200
.meas tran vdout0_11ck43 FIND v(dout0_11) AT=2200.25n

* CHECK dout0_12 Vdout0_12ck43 = 0 time = 2200
.meas tran vdout0_12ck43 FIND v(dout0_12) AT=2200.25n

* CHECK dout0_13 Vdout0_13ck43 = 1.8 time = 2200
.meas tran vdout0_13ck43 FIND v(dout0_13) AT=2200.25n

* CHECK dout0_14 Vdout0_14ck43 = 1.8 time = 2200
.meas tran vdout0_14ck43 FIND v(dout0_14) AT=2200.25n

* CHECK dout0_15 Vdout0_15ck43 = 0 time = 2200
.meas tran vdout0_15ck43 FIND v(dout0_15) AT=2200.25n

* CHECK dout0_0 Vdout0_0ck44 = 0 time = 2250
.meas tran vdout0_0ck44 FIND v(dout0_0) AT=2250.25n

* CHECK dout0_1 Vdout0_1ck44 = 0 time = 2250
.meas tran vdout0_1ck44 FIND v(dout0_1) AT=2250.25n

* CHECK dout0_2 Vdout0_2ck44 = 0 time = 2250
.meas tran vdout0_2ck44 FIND v(dout0_2) AT=2250.25n

* CHECK dout0_3 Vdout0_3ck44 = 0 time = 2250
.meas tran vdout0_3ck44 FIND v(dout0_3) AT=2250.25n

* CHECK dout0_4 Vdout0_4ck44 = 1.8 time = 2250
.meas tran vdout0_4ck44 FIND v(dout0_4) AT=2250.25n

* CHECK dout0_5 Vdout0_5ck44 = 0 time = 2250
.meas tran vdout0_5ck44 FIND v(dout0_5) AT=2250.25n

* CHECK dout0_6 Vdout0_6ck44 = 0 time = 2250
.meas tran vdout0_6ck44 FIND v(dout0_6) AT=2250.25n

* CHECK dout0_7 Vdout0_7ck44 = 1.8 time = 2250
.meas tran vdout0_7ck44 FIND v(dout0_7) AT=2250.25n

* CHECK dout0_8 Vdout0_8ck44 = 0 time = 2250
.meas tran vdout0_8ck44 FIND v(dout0_8) AT=2250.25n

* CHECK dout0_9 Vdout0_9ck44 = 0 time = 2250
.meas tran vdout0_9ck44 FIND v(dout0_9) AT=2250.25n

* CHECK dout0_10 Vdout0_10ck44 = 0 time = 2250
.meas tran vdout0_10ck44 FIND v(dout0_10) AT=2250.25n

* CHECK dout0_11 Vdout0_11ck44 = 0 time = 2250
.meas tran vdout0_11ck44 FIND v(dout0_11) AT=2250.25n

* CHECK dout0_12 Vdout0_12ck44 = 1.8 time = 2250
.meas tran vdout0_12ck44 FIND v(dout0_12) AT=2250.25n

* CHECK dout0_13 Vdout0_13ck44 = 0 time = 2250
.meas tran vdout0_13ck44 FIND v(dout0_13) AT=2250.25n

* CHECK dout0_14 Vdout0_14ck44 = 0 time = 2250
.meas tran vdout0_14ck44 FIND v(dout0_14) AT=2250.25n

* CHECK dout0_15 Vdout0_15ck44 = 0 time = 2250
.meas tran vdout0_15ck44 FIND v(dout0_15) AT=2250.25n

* CHECK dout0_0 Vdout0_0ck48 = 0 time = 2450
.meas tran vdout0_0ck48 FIND v(dout0_0) AT=2450.25n

* CHECK dout0_1 Vdout0_1ck48 = 0 time = 2450
.meas tran vdout0_1ck48 FIND v(dout0_1) AT=2450.25n

* CHECK dout0_2 Vdout0_2ck48 = 0 time = 2450
.meas tran vdout0_2ck48 FIND v(dout0_2) AT=2450.25n

* CHECK dout0_3 Vdout0_3ck48 = 1.8 time = 2450
.meas tran vdout0_3ck48 FIND v(dout0_3) AT=2450.25n

* CHECK dout0_4 Vdout0_4ck48 = 0 time = 2450
.meas tran vdout0_4ck48 FIND v(dout0_4) AT=2450.25n

* CHECK dout0_5 Vdout0_5ck48 = 0 time = 2450
.meas tran vdout0_5ck48 FIND v(dout0_5) AT=2450.25n

* CHECK dout0_6 Vdout0_6ck48 = 1.8 time = 2450
.meas tran vdout0_6ck48 FIND v(dout0_6) AT=2450.25n

* CHECK dout0_7 Vdout0_7ck48 = 1.8 time = 2450
.meas tran vdout0_7ck48 FIND v(dout0_7) AT=2450.25n

* CHECK dout0_8 Vdout0_8ck48 = 0 time = 2450
.meas tran vdout0_8ck48 FIND v(dout0_8) AT=2450.25n

* CHECK dout0_9 Vdout0_9ck48 = 0 time = 2450
.meas tran vdout0_9ck48 FIND v(dout0_9) AT=2450.25n

* CHECK dout0_10 Vdout0_10ck48 = 0 time = 2450
.meas tran vdout0_10ck48 FIND v(dout0_10) AT=2450.25n

* CHECK dout0_11 Vdout0_11ck48 = 0 time = 2450
.meas tran vdout0_11ck48 FIND v(dout0_11) AT=2450.25n

* CHECK dout0_12 Vdout0_12ck48 = 1.8 time = 2450
.meas tran vdout0_12ck48 FIND v(dout0_12) AT=2450.25n

* CHECK dout0_13 Vdout0_13ck48 = 1.8 time = 2450
.meas tran vdout0_13ck48 FIND v(dout0_13) AT=2450.25n

* CHECK dout0_14 Vdout0_14ck48 = 1.8 time = 2450
.meas tran vdout0_14ck48 FIND v(dout0_14) AT=2450.25n

* CHECK dout0_15 Vdout0_15ck48 = 1.8 time = 2450
.meas tran vdout0_15ck48 FIND v(dout0_15) AT=2450.25n

* CHECK dout0_0 Vdout0_0ck50 = 0 time = 2550
.meas tran vdout0_0ck50 FIND v(dout0_0) AT=2550.25n

* CHECK dout0_1 Vdout0_1ck50 = 0 time = 2550
.meas tran vdout0_1ck50 FIND v(dout0_1) AT=2550.25n

* CHECK dout0_2 Vdout0_2ck50 = 0 time = 2550
.meas tran vdout0_2ck50 FIND v(dout0_2) AT=2550.25n

* CHECK dout0_3 Vdout0_3ck50 = 0 time = 2550
.meas tran vdout0_3ck50 FIND v(dout0_3) AT=2550.25n

* CHECK dout0_4 Vdout0_4ck50 = 0 time = 2550
.meas tran vdout0_4ck50 FIND v(dout0_4) AT=2550.25n

* CHECK dout0_5 Vdout0_5ck50 = 1.8 time = 2550
.meas tran vdout0_5ck50 FIND v(dout0_5) AT=2550.25n

* CHECK dout0_6 Vdout0_6ck50 = 0 time = 2550
.meas tran vdout0_6ck50 FIND v(dout0_6) AT=2550.25n

* CHECK dout0_7 Vdout0_7ck50 = 1.8 time = 2550
.meas tran vdout0_7ck50 FIND v(dout0_7) AT=2550.25n

* CHECK dout0_8 Vdout0_8ck50 = 0 time = 2550
.meas tran vdout0_8ck50 FIND v(dout0_8) AT=2550.25n

* CHECK dout0_9 Vdout0_9ck50 = 1.8 time = 2550
.meas tran vdout0_9ck50 FIND v(dout0_9) AT=2550.25n

* CHECK dout0_10 Vdout0_10ck50 = 1.8 time = 2550
.meas tran vdout0_10ck50 FIND v(dout0_10) AT=2550.25n

* CHECK dout0_11 Vdout0_11ck50 = 0 time = 2550
.meas tran vdout0_11ck50 FIND v(dout0_11) AT=2550.25n

* CHECK dout0_12 Vdout0_12ck50 = 0 time = 2550
.meas tran vdout0_12ck50 FIND v(dout0_12) AT=2550.25n

* CHECK dout0_13 Vdout0_13ck50 = 1.8 time = 2550
.meas tran vdout0_13ck50 FIND v(dout0_13) AT=2550.25n

* CHECK dout0_14 Vdout0_14ck50 = 1.8 time = 2550
.meas tran vdout0_14ck50 FIND v(dout0_14) AT=2550.25n

* CHECK dout0_15 Vdout0_15ck50 = 0 time = 2550
.meas tran vdout0_15ck50 FIND v(dout0_15) AT=2550.25n

* CHECK dout0_0 Vdout0_0ck51 = 0 time = 2600
.meas tran vdout0_0ck51 FIND v(dout0_0) AT=2600.25n

* CHECK dout0_1 Vdout0_1ck51 = 0 time = 2600
.meas tran vdout0_1ck51 FIND v(dout0_1) AT=2600.25n

* CHECK dout0_2 Vdout0_2ck51 = 0 time = 2600
.meas tran vdout0_2ck51 FIND v(dout0_2) AT=2600.25n

* CHECK dout0_3 Vdout0_3ck51 = 1.8 time = 2600
.meas tran vdout0_3ck51 FIND v(dout0_3) AT=2600.25n

* CHECK dout0_4 Vdout0_4ck51 = 0 time = 2600
.meas tran vdout0_4ck51 FIND v(dout0_4) AT=2600.25n

* CHECK dout0_5 Vdout0_5ck51 = 0 time = 2600
.meas tran vdout0_5ck51 FIND v(dout0_5) AT=2600.25n

* CHECK dout0_6 Vdout0_6ck51 = 1.8 time = 2600
.meas tran vdout0_6ck51 FIND v(dout0_6) AT=2600.25n

* CHECK dout0_7 Vdout0_7ck51 = 1.8 time = 2600
.meas tran vdout0_7ck51 FIND v(dout0_7) AT=2600.25n

* CHECK dout0_8 Vdout0_8ck51 = 0 time = 2600
.meas tran vdout0_8ck51 FIND v(dout0_8) AT=2600.25n

* CHECK dout0_9 Vdout0_9ck51 = 0 time = 2600
.meas tran vdout0_9ck51 FIND v(dout0_9) AT=2600.25n

* CHECK dout0_10 Vdout0_10ck51 = 0 time = 2600
.meas tran vdout0_10ck51 FIND v(dout0_10) AT=2600.25n

* CHECK dout0_11 Vdout0_11ck51 = 0 time = 2600
.meas tran vdout0_11ck51 FIND v(dout0_11) AT=2600.25n

* CHECK dout0_12 Vdout0_12ck51 = 1.8 time = 2600
.meas tran vdout0_12ck51 FIND v(dout0_12) AT=2600.25n

* CHECK dout0_13 Vdout0_13ck51 = 1.8 time = 2600
.meas tran vdout0_13ck51 FIND v(dout0_13) AT=2600.25n

* CHECK dout0_14 Vdout0_14ck51 = 1.8 time = 2600
.meas tran vdout0_14ck51 FIND v(dout0_14) AT=2600.25n

* CHECK dout0_15 Vdout0_15ck51 = 1.8 time = 2600
.meas tran vdout0_15ck51 FIND v(dout0_15) AT=2600.25n

* CHECK dout0_0 Vdout0_0ck52 = 0 time = 2650
.meas tran vdout0_0ck52 FIND v(dout0_0) AT=2650.25n

* CHECK dout0_1 Vdout0_1ck52 = 0 time = 2650
.meas tran vdout0_1ck52 FIND v(dout0_1) AT=2650.25n

* CHECK dout0_2 Vdout0_2ck52 = 0 time = 2650
.meas tran vdout0_2ck52 FIND v(dout0_2) AT=2650.25n

* CHECK dout0_3 Vdout0_3ck52 = 0 time = 2650
.meas tran vdout0_3ck52 FIND v(dout0_3) AT=2650.25n

* CHECK dout0_4 Vdout0_4ck52 = 0 time = 2650
.meas tran vdout0_4ck52 FIND v(dout0_4) AT=2650.25n

* CHECK dout0_5 Vdout0_5ck52 = 1.8 time = 2650
.meas tran vdout0_5ck52 FIND v(dout0_5) AT=2650.25n

* CHECK dout0_6 Vdout0_6ck52 = 0 time = 2650
.meas tran vdout0_6ck52 FIND v(dout0_6) AT=2650.25n

* CHECK dout0_7 Vdout0_7ck52 = 1.8 time = 2650
.meas tran vdout0_7ck52 FIND v(dout0_7) AT=2650.25n

* CHECK dout0_8 Vdout0_8ck52 = 0 time = 2650
.meas tran vdout0_8ck52 FIND v(dout0_8) AT=2650.25n

* CHECK dout0_9 Vdout0_9ck52 = 1.8 time = 2650
.meas tran vdout0_9ck52 FIND v(dout0_9) AT=2650.25n

* CHECK dout0_10 Vdout0_10ck52 = 1.8 time = 2650
.meas tran vdout0_10ck52 FIND v(dout0_10) AT=2650.25n

* CHECK dout0_11 Vdout0_11ck52 = 0 time = 2650
.meas tran vdout0_11ck52 FIND v(dout0_11) AT=2650.25n

* CHECK dout0_12 Vdout0_12ck52 = 0 time = 2650
.meas tran vdout0_12ck52 FIND v(dout0_12) AT=2650.25n

* CHECK dout0_13 Vdout0_13ck52 = 1.8 time = 2650
.meas tran vdout0_13ck52 FIND v(dout0_13) AT=2650.25n

* CHECK dout0_14 Vdout0_14ck52 = 1.8 time = 2650
.meas tran vdout0_14ck52 FIND v(dout0_14) AT=2650.25n

* CHECK dout0_15 Vdout0_15ck52 = 0 time = 2650
.meas tran vdout0_15ck52 FIND v(dout0_15) AT=2650.25n

* CHECK dout0_0 Vdout0_0ck53 = 0 time = 2700
.meas tran vdout0_0ck53 FIND v(dout0_0) AT=2700.25n

* CHECK dout0_1 Vdout0_1ck53 = 0 time = 2700
.meas tran vdout0_1ck53 FIND v(dout0_1) AT=2700.25n

* CHECK dout0_2 Vdout0_2ck53 = 0 time = 2700
.meas tran vdout0_2ck53 FIND v(dout0_2) AT=2700.25n

* CHECK dout0_3 Vdout0_3ck53 = 1.8 time = 2700
.meas tran vdout0_3ck53 FIND v(dout0_3) AT=2700.25n

* CHECK dout0_4 Vdout0_4ck53 = 0 time = 2700
.meas tran vdout0_4ck53 FIND v(dout0_4) AT=2700.25n

* CHECK dout0_5 Vdout0_5ck53 = 1.8 time = 2700
.meas tran vdout0_5ck53 FIND v(dout0_5) AT=2700.25n

* CHECK dout0_6 Vdout0_6ck53 = 1.8 time = 2700
.meas tran vdout0_6ck53 FIND v(dout0_6) AT=2700.25n

* CHECK dout0_7 Vdout0_7ck53 = 1.8 time = 2700
.meas tran vdout0_7ck53 FIND v(dout0_7) AT=2700.25n

* CHECK dout0_8 Vdout0_8ck53 = 1.8 time = 2700
.meas tran vdout0_8ck53 FIND v(dout0_8) AT=2700.25n

* CHECK dout0_9 Vdout0_9ck53 = 0 time = 2700
.meas tran vdout0_9ck53 FIND v(dout0_9) AT=2700.25n

* CHECK dout0_10 Vdout0_10ck53 = 1.8 time = 2700
.meas tran vdout0_10ck53 FIND v(dout0_10) AT=2700.25n

* CHECK dout0_11 Vdout0_11ck53 = 1.8 time = 2700
.meas tran vdout0_11ck53 FIND v(dout0_11) AT=2700.25n

* CHECK dout0_12 Vdout0_12ck53 = 0 time = 2700
.meas tran vdout0_12ck53 FIND v(dout0_12) AT=2700.25n

* CHECK dout0_13 Vdout0_13ck53 = 1.8 time = 2700
.meas tran vdout0_13ck53 FIND v(dout0_13) AT=2700.25n

* CHECK dout0_14 Vdout0_14ck53 = 1.8 time = 2700
.meas tran vdout0_14ck53 FIND v(dout0_14) AT=2700.25n

* CHECK dout0_15 Vdout0_15ck53 = 0 time = 2700
.meas tran vdout0_15ck53 FIND v(dout0_15) AT=2700.25n

* CHECK dout0_0 Vdout0_0ck55 = 0 time = 2800
.meas tran vdout0_0ck55 FIND v(dout0_0) AT=2800.25n

* CHECK dout0_1 Vdout0_1ck55 = 0 time = 2800
.meas tran vdout0_1ck55 FIND v(dout0_1) AT=2800.25n

* CHECK dout0_2 Vdout0_2ck55 = 1.8 time = 2800
.meas tran vdout0_2ck55 FIND v(dout0_2) AT=2800.25n

* CHECK dout0_3 Vdout0_3ck55 = 0 time = 2800
.meas tran vdout0_3ck55 FIND v(dout0_3) AT=2800.25n

* CHECK dout0_4 Vdout0_4ck55 = 1.8 time = 2800
.meas tran vdout0_4ck55 FIND v(dout0_4) AT=2800.25n

* CHECK dout0_5 Vdout0_5ck55 = 1.8 time = 2800
.meas tran vdout0_5ck55 FIND v(dout0_5) AT=2800.25n

* CHECK dout0_6 Vdout0_6ck55 = 1.8 time = 2800
.meas tran vdout0_6ck55 FIND v(dout0_6) AT=2800.25n

* CHECK dout0_7 Vdout0_7ck55 = 1.8 time = 2800
.meas tran vdout0_7ck55 FIND v(dout0_7) AT=2800.25n

* CHECK dout0_8 Vdout0_8ck55 = 0 time = 2800
.meas tran vdout0_8ck55 FIND v(dout0_8) AT=2800.25n

* CHECK dout0_9 Vdout0_9ck55 = 0 time = 2800
.meas tran vdout0_9ck55 FIND v(dout0_9) AT=2800.25n

* CHECK dout0_10 Vdout0_10ck55 = 0 time = 2800
.meas tran vdout0_10ck55 FIND v(dout0_10) AT=2800.25n

* CHECK dout0_11 Vdout0_11ck55 = 0 time = 2800
.meas tran vdout0_11ck55 FIND v(dout0_11) AT=2800.25n

* CHECK dout0_12 Vdout0_12ck55 = 1.8 time = 2800
.meas tran vdout0_12ck55 FIND v(dout0_12) AT=2800.25n

* CHECK dout0_13 Vdout0_13ck55 = 0 time = 2800
.meas tran vdout0_13ck55 FIND v(dout0_13) AT=2800.25n

* CHECK dout0_14 Vdout0_14ck55 = 1.8 time = 2800
.meas tran vdout0_14ck55 FIND v(dout0_14) AT=2800.25n

* CHECK dout0_15 Vdout0_15ck55 = 1.8 time = 2800
.meas tran vdout0_15ck55 FIND v(dout0_15) AT=2800.25n

* CHECK dout0_0 Vdout0_0ck59 = 1.8 time = 3000
.meas tran vdout0_0ck59 FIND v(dout0_0) AT=3000.25n

* CHECK dout0_1 Vdout0_1ck59 = 0 time = 3000
.meas tran vdout0_1ck59 FIND v(dout0_1) AT=3000.25n

* CHECK dout0_2 Vdout0_2ck59 = 0 time = 3000
.meas tran vdout0_2ck59 FIND v(dout0_2) AT=3000.25n

* CHECK dout0_3 Vdout0_3ck59 = 1.8 time = 3000
.meas tran vdout0_3ck59 FIND v(dout0_3) AT=3000.25n

* CHECK dout0_4 Vdout0_4ck59 = 1.8 time = 3000
.meas tran vdout0_4ck59 FIND v(dout0_4) AT=3000.25n

* CHECK dout0_5 Vdout0_5ck59 = 1.8 time = 3000
.meas tran vdout0_5ck59 FIND v(dout0_5) AT=3000.25n

* CHECK dout0_6 Vdout0_6ck59 = 1.8 time = 3000
.meas tran vdout0_6ck59 FIND v(dout0_6) AT=3000.25n

* CHECK dout0_7 Vdout0_7ck59 = 0 time = 3000
.meas tran vdout0_7ck59 FIND v(dout0_7) AT=3000.25n

* CHECK dout0_8 Vdout0_8ck59 = 1.8 time = 3000
.meas tran vdout0_8ck59 FIND v(dout0_8) AT=3000.25n

* CHECK dout0_9 Vdout0_9ck59 = 1.8 time = 3000
.meas tran vdout0_9ck59 FIND v(dout0_9) AT=3000.25n

* CHECK dout0_10 Vdout0_10ck59 = 1.8 time = 3000
.meas tran vdout0_10ck59 FIND v(dout0_10) AT=3000.25n

* CHECK dout0_11 Vdout0_11ck59 = 1.8 time = 3000
.meas tran vdout0_11ck59 FIND v(dout0_11) AT=3000.25n

* CHECK dout0_12 Vdout0_12ck59 = 1.8 time = 3000
.meas tran vdout0_12ck59 FIND v(dout0_12) AT=3000.25n

* CHECK dout0_13 Vdout0_13ck59 = 1.8 time = 3000
.meas tran vdout0_13ck59 FIND v(dout0_13) AT=3000.25n

* CHECK dout0_14 Vdout0_14ck59 = 1.8 time = 3000
.meas tran vdout0_14ck59 FIND v(dout0_14) AT=3000.25n

* CHECK dout0_15 Vdout0_15ck59 = 1.8 time = 3000
.meas tran vdout0_15ck59 FIND v(dout0_15) AT=3000.25n

* CHECK dout0_0 Vdout0_0ck61 = 1.8 time = 3100
.meas tran vdout0_0ck61 FIND v(dout0_0) AT=3100.25n

* CHECK dout0_1 Vdout0_1ck61 = 1.8 time = 3100
.meas tran vdout0_1ck61 FIND v(dout0_1) AT=3100.25n

* CHECK dout0_2 Vdout0_2ck61 = 1.8 time = 3100
.meas tran vdout0_2ck61 FIND v(dout0_2) AT=3100.25n

* CHECK dout0_3 Vdout0_3ck61 = 0 time = 3100
.meas tran vdout0_3ck61 FIND v(dout0_3) AT=3100.25n

* CHECK dout0_4 Vdout0_4ck61 = 0 time = 3100
.meas tran vdout0_4ck61 FIND v(dout0_4) AT=3100.25n

* CHECK dout0_5 Vdout0_5ck61 = 0 time = 3100
.meas tran vdout0_5ck61 FIND v(dout0_5) AT=3100.25n

* CHECK dout0_6 Vdout0_6ck61 = 0 time = 3100
.meas tran vdout0_6ck61 FIND v(dout0_6) AT=3100.25n

* CHECK dout0_7 Vdout0_7ck61 = 0 time = 3100
.meas tran vdout0_7ck61 FIND v(dout0_7) AT=3100.25n

* CHECK dout0_8 Vdout0_8ck61 = 1.8 time = 3100
.meas tran vdout0_8ck61 FIND v(dout0_8) AT=3100.25n

* CHECK dout0_9 Vdout0_9ck61 = 1.8 time = 3100
.meas tran vdout0_9ck61 FIND v(dout0_9) AT=3100.25n

* CHECK dout0_10 Vdout0_10ck61 = 0 time = 3100
.meas tran vdout0_10ck61 FIND v(dout0_10) AT=3100.25n

* CHECK dout0_11 Vdout0_11ck61 = 0 time = 3100
.meas tran vdout0_11ck61 FIND v(dout0_11) AT=3100.25n

* CHECK dout0_12 Vdout0_12ck61 = 1.8 time = 3100
.meas tran vdout0_12ck61 FIND v(dout0_12) AT=3100.25n

* CHECK dout0_13 Vdout0_13ck61 = 0 time = 3100
.meas tran vdout0_13ck61 FIND v(dout0_13) AT=3100.25n

* CHECK dout0_14 Vdout0_14ck61 = 0 time = 3100
.meas tran vdout0_14ck61 FIND v(dout0_14) AT=3100.25n

* CHECK dout0_15 Vdout0_15ck61 = 0 time = 3100
.meas tran vdout0_15ck61 FIND v(dout0_15) AT=3100.25n

* CHECK dout0_0 Vdout0_0ck67 = 0 time = 3400
.meas tran vdout0_0ck67 FIND v(dout0_0) AT=3400.25n

* CHECK dout0_1 Vdout0_1ck67 = 0 time = 3400
.meas tran vdout0_1ck67 FIND v(dout0_1) AT=3400.25n

* CHECK dout0_2 Vdout0_2ck67 = 0 time = 3400
.meas tran vdout0_2ck67 FIND v(dout0_2) AT=3400.25n

* CHECK dout0_3 Vdout0_3ck67 = 1.8 time = 3400
.meas tran vdout0_3ck67 FIND v(dout0_3) AT=3400.25n

* CHECK dout0_4 Vdout0_4ck67 = 1.8 time = 3400
.meas tran vdout0_4ck67 FIND v(dout0_4) AT=3400.25n

* CHECK dout0_5 Vdout0_5ck67 = 1.8 time = 3400
.meas tran vdout0_5ck67 FIND v(dout0_5) AT=3400.25n

* CHECK dout0_6 Vdout0_6ck67 = 1.8 time = 3400
.meas tran vdout0_6ck67 FIND v(dout0_6) AT=3400.25n

* CHECK dout0_7 Vdout0_7ck67 = 0 time = 3400
.meas tran vdout0_7ck67 FIND v(dout0_7) AT=3400.25n

* CHECK dout0_8 Vdout0_8ck67 = 0 time = 3400
.meas tran vdout0_8ck67 FIND v(dout0_8) AT=3400.25n

* CHECK dout0_9 Vdout0_9ck67 = 1.8 time = 3400
.meas tran vdout0_9ck67 FIND v(dout0_9) AT=3400.25n

* CHECK dout0_10 Vdout0_10ck67 = 1.8 time = 3400
.meas tran vdout0_10ck67 FIND v(dout0_10) AT=3400.25n

* CHECK dout0_11 Vdout0_11ck67 = 0 time = 3400
.meas tran vdout0_11ck67 FIND v(dout0_11) AT=3400.25n

* CHECK dout0_12 Vdout0_12ck67 = 0 time = 3400
.meas tran vdout0_12ck67 FIND v(dout0_12) AT=3400.25n

* CHECK dout0_13 Vdout0_13ck67 = 1.8 time = 3400
.meas tran vdout0_13ck67 FIND v(dout0_13) AT=3400.25n

* CHECK dout0_14 Vdout0_14ck67 = 1.8 time = 3400
.meas tran vdout0_14ck67 FIND v(dout0_14) AT=3400.25n

* CHECK dout0_15 Vdout0_15ck67 = 1.8 time = 3400
.meas tran vdout0_15ck67 FIND v(dout0_15) AT=3400.25n

* CHECK dout0_0 Vdout0_0ck68 = 1.8 time = 3450
.meas tran vdout0_0ck68 FIND v(dout0_0) AT=3450.25n

* CHECK dout0_1 Vdout0_1ck68 = 1.8 time = 3450
.meas tran vdout0_1ck68 FIND v(dout0_1) AT=3450.25n

* CHECK dout0_2 Vdout0_2ck68 = 1.8 time = 3450
.meas tran vdout0_2ck68 FIND v(dout0_2) AT=3450.25n

* CHECK dout0_3 Vdout0_3ck68 = 0 time = 3450
.meas tran vdout0_3ck68 FIND v(dout0_3) AT=3450.25n

* CHECK dout0_4 Vdout0_4ck68 = 0 time = 3450
.meas tran vdout0_4ck68 FIND v(dout0_4) AT=3450.25n

* CHECK dout0_5 Vdout0_5ck68 = 0 time = 3450
.meas tran vdout0_5ck68 FIND v(dout0_5) AT=3450.25n

* CHECK dout0_6 Vdout0_6ck68 = 0 time = 3450
.meas tran vdout0_6ck68 FIND v(dout0_6) AT=3450.25n

* CHECK dout0_7 Vdout0_7ck68 = 0 time = 3450
.meas tran vdout0_7ck68 FIND v(dout0_7) AT=3450.25n

* CHECK dout0_8 Vdout0_8ck68 = 1.8 time = 3450
.meas tran vdout0_8ck68 FIND v(dout0_8) AT=3450.25n

* CHECK dout0_9 Vdout0_9ck68 = 1.8 time = 3450
.meas tran vdout0_9ck68 FIND v(dout0_9) AT=3450.25n

* CHECK dout0_10 Vdout0_10ck68 = 0 time = 3450
.meas tran vdout0_10ck68 FIND v(dout0_10) AT=3450.25n

* CHECK dout0_11 Vdout0_11ck68 = 0 time = 3450
.meas tran vdout0_11ck68 FIND v(dout0_11) AT=3450.25n

* CHECK dout0_12 Vdout0_12ck68 = 1.8 time = 3450
.meas tran vdout0_12ck68 FIND v(dout0_12) AT=3450.25n

* CHECK dout0_13 Vdout0_13ck68 = 0 time = 3450
.meas tran vdout0_13ck68 FIND v(dout0_13) AT=3450.25n

* CHECK dout0_14 Vdout0_14ck68 = 0 time = 3450
.meas tran vdout0_14ck68 FIND v(dout0_14) AT=3450.25n

* CHECK dout0_15 Vdout0_15ck68 = 0 time = 3450
.meas tran vdout0_15ck68 FIND v(dout0_15) AT=3450.25n

* CHECK dout0_0 Vdout0_0ck74 = 1.8 time = 3750
.meas tran vdout0_0ck74 FIND v(dout0_0) AT=3750.25n

* CHECK dout0_1 Vdout0_1ck74 = 1.8 time = 3750
.meas tran vdout0_1ck74 FIND v(dout0_1) AT=3750.25n

* CHECK dout0_2 Vdout0_2ck74 = 1.8 time = 3750
.meas tran vdout0_2ck74 FIND v(dout0_2) AT=3750.25n

* CHECK dout0_3 Vdout0_3ck74 = 0 time = 3750
.meas tran vdout0_3ck74 FIND v(dout0_3) AT=3750.25n

* CHECK dout0_4 Vdout0_4ck74 = 0 time = 3750
.meas tran vdout0_4ck74 FIND v(dout0_4) AT=3750.25n

* CHECK dout0_5 Vdout0_5ck74 = 0 time = 3750
.meas tran vdout0_5ck74 FIND v(dout0_5) AT=3750.25n

* CHECK dout0_6 Vdout0_6ck74 = 0 time = 3750
.meas tran vdout0_6ck74 FIND v(dout0_6) AT=3750.25n

* CHECK dout0_7 Vdout0_7ck74 = 0 time = 3750
.meas tran vdout0_7ck74 FIND v(dout0_7) AT=3750.25n

* CHECK dout0_8 Vdout0_8ck74 = 1.8 time = 3750
.meas tran vdout0_8ck74 FIND v(dout0_8) AT=3750.25n

* CHECK dout0_9 Vdout0_9ck74 = 1.8 time = 3750
.meas tran vdout0_9ck74 FIND v(dout0_9) AT=3750.25n

* CHECK dout0_10 Vdout0_10ck74 = 0 time = 3750
.meas tran vdout0_10ck74 FIND v(dout0_10) AT=3750.25n

* CHECK dout0_11 Vdout0_11ck74 = 0 time = 3750
.meas tran vdout0_11ck74 FIND v(dout0_11) AT=3750.25n

* CHECK dout0_12 Vdout0_12ck74 = 1.8 time = 3750
.meas tran vdout0_12ck74 FIND v(dout0_12) AT=3750.25n

* CHECK dout0_13 Vdout0_13ck74 = 0 time = 3750
.meas tran vdout0_13ck74 FIND v(dout0_13) AT=3750.25n

* CHECK dout0_14 Vdout0_14ck74 = 0 time = 3750
.meas tran vdout0_14ck74 FIND v(dout0_14) AT=3750.25n

* CHECK dout0_15 Vdout0_15ck74 = 0 time = 3750
.meas tran vdout0_15ck74 FIND v(dout0_15) AT=3750.25n

* CHECK dout0_0 Vdout0_0ck75 = 1.8 time = 3800
.meas tran vdout0_0ck75 FIND v(dout0_0) AT=3800.25n

* CHECK dout0_1 Vdout0_1ck75 = 0 time = 3800
.meas tran vdout0_1ck75 FIND v(dout0_1) AT=3800.25n

* CHECK dout0_2 Vdout0_2ck75 = 1.8 time = 3800
.meas tran vdout0_2ck75 FIND v(dout0_2) AT=3800.25n

* CHECK dout0_3 Vdout0_3ck75 = 1.8 time = 3800
.meas tran vdout0_3ck75 FIND v(dout0_3) AT=3800.25n

* CHECK dout0_4 Vdout0_4ck75 = 0 time = 3800
.meas tran vdout0_4ck75 FIND v(dout0_4) AT=3800.25n

* CHECK dout0_5 Vdout0_5ck75 = 1.8 time = 3800
.meas tran vdout0_5ck75 FIND v(dout0_5) AT=3800.25n

* CHECK dout0_6 Vdout0_6ck75 = 0 time = 3800
.meas tran vdout0_6ck75 FIND v(dout0_6) AT=3800.25n

* CHECK dout0_7 Vdout0_7ck75 = 0 time = 3800
.meas tran vdout0_7ck75 FIND v(dout0_7) AT=3800.25n

* CHECK dout0_8 Vdout0_8ck75 = 1.8 time = 3800
.meas tran vdout0_8ck75 FIND v(dout0_8) AT=3800.25n

* CHECK dout0_9 Vdout0_9ck75 = 0 time = 3800
.meas tran vdout0_9ck75 FIND v(dout0_9) AT=3800.25n

* CHECK dout0_10 Vdout0_10ck75 = 1.8 time = 3800
.meas tran vdout0_10ck75 FIND v(dout0_10) AT=3800.25n

* CHECK dout0_11 Vdout0_11ck75 = 1.8 time = 3800
.meas tran vdout0_11ck75 FIND v(dout0_11) AT=3800.25n

* CHECK dout0_12 Vdout0_12ck75 = 0 time = 3800
.meas tran vdout0_12ck75 FIND v(dout0_12) AT=3800.25n

* CHECK dout0_13 Vdout0_13ck75 = 0 time = 3800
.meas tran vdout0_13ck75 FIND v(dout0_13) AT=3800.25n

* CHECK dout0_14 Vdout0_14ck75 = 1.8 time = 3800
.meas tran vdout0_14ck75 FIND v(dout0_14) AT=3800.25n

* CHECK dout0_15 Vdout0_15ck75 = 0 time = 3800
.meas tran vdout0_15ck75 FIND v(dout0_15) AT=3800.25n

* CHECK dout0_0 Vdout0_0ck76 = 0 time = 3850
.meas tran vdout0_0ck76 FIND v(dout0_0) AT=3850.25n

* CHECK dout0_1 Vdout0_1ck76 = 0 time = 3850
.meas tran vdout0_1ck76 FIND v(dout0_1) AT=3850.25n

* CHECK dout0_2 Vdout0_2ck76 = 1.8 time = 3850
.meas tran vdout0_2ck76 FIND v(dout0_2) AT=3850.25n

* CHECK dout0_3 Vdout0_3ck76 = 0 time = 3850
.meas tran vdout0_3ck76 FIND v(dout0_3) AT=3850.25n

* CHECK dout0_4 Vdout0_4ck76 = 1.8 time = 3850
.meas tran vdout0_4ck76 FIND v(dout0_4) AT=3850.25n

* CHECK dout0_5 Vdout0_5ck76 = 1.8 time = 3850
.meas tran vdout0_5ck76 FIND v(dout0_5) AT=3850.25n

* CHECK dout0_6 Vdout0_6ck76 = 1.8 time = 3850
.meas tran vdout0_6ck76 FIND v(dout0_6) AT=3850.25n

* CHECK dout0_7 Vdout0_7ck76 = 1.8 time = 3850
.meas tran vdout0_7ck76 FIND v(dout0_7) AT=3850.25n

* CHECK dout0_8 Vdout0_8ck76 = 0 time = 3850
.meas tran vdout0_8ck76 FIND v(dout0_8) AT=3850.25n

* CHECK dout0_9 Vdout0_9ck76 = 0 time = 3850
.meas tran vdout0_9ck76 FIND v(dout0_9) AT=3850.25n

* CHECK dout0_10 Vdout0_10ck76 = 0 time = 3850
.meas tran vdout0_10ck76 FIND v(dout0_10) AT=3850.25n

* CHECK dout0_11 Vdout0_11ck76 = 0 time = 3850
.meas tran vdout0_11ck76 FIND v(dout0_11) AT=3850.25n

* CHECK dout0_12 Vdout0_12ck76 = 1.8 time = 3850
.meas tran vdout0_12ck76 FIND v(dout0_12) AT=3850.25n

* CHECK dout0_13 Vdout0_13ck76 = 0 time = 3850
.meas tran vdout0_13ck76 FIND v(dout0_13) AT=3850.25n

* CHECK dout0_14 Vdout0_14ck76 = 1.8 time = 3850
.meas tran vdout0_14ck76 FIND v(dout0_14) AT=3850.25n

* CHECK dout0_15 Vdout0_15ck76 = 1.8 time = 3850
.meas tran vdout0_15ck76 FIND v(dout0_15) AT=3850.25n

* CHECK dout0_0 Vdout0_0ck78 = 1.8 time = 3950
.meas tran vdout0_0ck78 FIND v(dout0_0) AT=3950.25n

* CHECK dout0_1 Vdout0_1ck78 = 0 time = 3950
.meas tran vdout0_1ck78 FIND v(dout0_1) AT=3950.25n

* CHECK dout0_2 Vdout0_2ck78 = 0 time = 3950
.meas tran vdout0_2ck78 FIND v(dout0_2) AT=3950.25n

* CHECK dout0_3 Vdout0_3ck78 = 1.8 time = 3950
.meas tran vdout0_3ck78 FIND v(dout0_3) AT=3950.25n

* CHECK dout0_4 Vdout0_4ck78 = 1.8 time = 3950
.meas tran vdout0_4ck78 FIND v(dout0_4) AT=3950.25n

* CHECK dout0_5 Vdout0_5ck78 = 1.8 time = 3950
.meas tran vdout0_5ck78 FIND v(dout0_5) AT=3950.25n

* CHECK dout0_6 Vdout0_6ck78 = 1.8 time = 3950
.meas tran vdout0_6ck78 FIND v(dout0_6) AT=3950.25n

* CHECK dout0_7 Vdout0_7ck78 = 0 time = 3950
.meas tran vdout0_7ck78 FIND v(dout0_7) AT=3950.25n

* CHECK dout0_8 Vdout0_8ck78 = 1.8 time = 3950
.meas tran vdout0_8ck78 FIND v(dout0_8) AT=3950.25n

* CHECK dout0_9 Vdout0_9ck78 = 1.8 time = 3950
.meas tran vdout0_9ck78 FIND v(dout0_9) AT=3950.25n

* CHECK dout0_10 Vdout0_10ck78 = 1.8 time = 3950
.meas tran vdout0_10ck78 FIND v(dout0_10) AT=3950.25n

* CHECK dout0_11 Vdout0_11ck78 = 1.8 time = 3950
.meas tran vdout0_11ck78 FIND v(dout0_11) AT=3950.25n

* CHECK dout0_12 Vdout0_12ck78 = 1.8 time = 3950
.meas tran vdout0_12ck78 FIND v(dout0_12) AT=3950.25n

* CHECK dout0_13 Vdout0_13ck78 = 1.8 time = 3950
.meas tran vdout0_13ck78 FIND v(dout0_13) AT=3950.25n

* CHECK dout0_14 Vdout0_14ck78 = 1.8 time = 3950
.meas tran vdout0_14ck78 FIND v(dout0_14) AT=3950.25n

* CHECK dout0_15 Vdout0_15ck78 = 1.8 time = 3950
.meas tran vdout0_15ck78 FIND v(dout0_15) AT=3950.25n

* CHECK dout0_0 Vdout0_0ck79 = 1.8 time = 4000
.meas tran vdout0_0ck79 FIND v(dout0_0) AT=4000.25n

* CHECK dout0_1 Vdout0_1ck79 = 0 time = 4000
.meas tran vdout0_1ck79 FIND v(dout0_1) AT=4000.25n

* CHECK dout0_2 Vdout0_2ck79 = 0 time = 4000
.meas tran vdout0_2ck79 FIND v(dout0_2) AT=4000.25n

* CHECK dout0_3 Vdout0_3ck79 = 1.8 time = 4000
.meas tran vdout0_3ck79 FIND v(dout0_3) AT=4000.25n

* CHECK dout0_4 Vdout0_4ck79 = 1.8 time = 4000
.meas tran vdout0_4ck79 FIND v(dout0_4) AT=4000.25n

* CHECK dout0_5 Vdout0_5ck79 = 1.8 time = 4000
.meas tran vdout0_5ck79 FIND v(dout0_5) AT=4000.25n

* CHECK dout0_6 Vdout0_6ck79 = 1.8 time = 4000
.meas tran vdout0_6ck79 FIND v(dout0_6) AT=4000.25n

* CHECK dout0_7 Vdout0_7ck79 = 0 time = 4000
.meas tran vdout0_7ck79 FIND v(dout0_7) AT=4000.25n

* CHECK dout0_8 Vdout0_8ck79 = 1.8 time = 4000
.meas tran vdout0_8ck79 FIND v(dout0_8) AT=4000.25n

* CHECK dout0_9 Vdout0_9ck79 = 1.8 time = 4000
.meas tran vdout0_9ck79 FIND v(dout0_9) AT=4000.25n

* CHECK dout0_10 Vdout0_10ck79 = 1.8 time = 4000
.meas tran vdout0_10ck79 FIND v(dout0_10) AT=4000.25n

* CHECK dout0_11 Vdout0_11ck79 = 1.8 time = 4000
.meas tran vdout0_11ck79 FIND v(dout0_11) AT=4000.25n

* CHECK dout0_12 Vdout0_12ck79 = 1.8 time = 4000
.meas tran vdout0_12ck79 FIND v(dout0_12) AT=4000.25n

* CHECK dout0_13 Vdout0_13ck79 = 1.8 time = 4000
.meas tran vdout0_13ck79 FIND v(dout0_13) AT=4000.25n

* CHECK dout0_14 Vdout0_14ck79 = 1.8 time = 4000
.meas tran vdout0_14ck79 FIND v(dout0_14) AT=4000.25n

* CHECK dout0_15 Vdout0_15ck79 = 1.8 time = 4000
.meas tran vdout0_15ck79 FIND v(dout0_15) AT=4000.25n

* CHECK dout0_0 Vdout0_0ck81 = 1.8 time = 4100
.meas tran vdout0_0ck81 FIND v(dout0_0) AT=4100.25n

* CHECK dout0_1 Vdout0_1ck81 = 0 time = 4100
.meas tran vdout0_1ck81 FIND v(dout0_1) AT=4100.25n

* CHECK dout0_2 Vdout0_2ck81 = 0 time = 4100
.meas tran vdout0_2ck81 FIND v(dout0_2) AT=4100.25n

* CHECK dout0_3 Vdout0_3ck81 = 1.8 time = 4100
.meas tran vdout0_3ck81 FIND v(dout0_3) AT=4100.25n

* CHECK dout0_4 Vdout0_4ck81 = 1.8 time = 4100
.meas tran vdout0_4ck81 FIND v(dout0_4) AT=4100.25n

* CHECK dout0_5 Vdout0_5ck81 = 1.8 time = 4100
.meas tran vdout0_5ck81 FIND v(dout0_5) AT=4100.25n

* CHECK dout0_6 Vdout0_6ck81 = 1.8 time = 4100
.meas tran vdout0_6ck81 FIND v(dout0_6) AT=4100.25n

* CHECK dout0_7 Vdout0_7ck81 = 0 time = 4100
.meas tran vdout0_7ck81 FIND v(dout0_7) AT=4100.25n

* CHECK dout0_8 Vdout0_8ck81 = 1.8 time = 4100
.meas tran vdout0_8ck81 FIND v(dout0_8) AT=4100.25n

* CHECK dout0_9 Vdout0_9ck81 = 1.8 time = 4100
.meas tran vdout0_9ck81 FIND v(dout0_9) AT=4100.25n

* CHECK dout0_10 Vdout0_10ck81 = 1.8 time = 4100
.meas tran vdout0_10ck81 FIND v(dout0_10) AT=4100.25n

* CHECK dout0_11 Vdout0_11ck81 = 1.8 time = 4100
.meas tran vdout0_11ck81 FIND v(dout0_11) AT=4100.25n

* CHECK dout0_12 Vdout0_12ck81 = 1.8 time = 4100
.meas tran vdout0_12ck81 FIND v(dout0_12) AT=4100.25n

* CHECK dout0_13 Vdout0_13ck81 = 1.8 time = 4100
.meas tran vdout0_13ck81 FIND v(dout0_13) AT=4100.25n

* CHECK dout0_14 Vdout0_14ck81 = 1.8 time = 4100
.meas tran vdout0_14ck81 FIND v(dout0_14) AT=4100.25n

* CHECK dout0_15 Vdout0_15ck81 = 1.8 time = 4100
.meas tran vdout0_15ck81 FIND v(dout0_15) AT=4100.25n

* CHECK dout0_0 Vdout0_0ck86 = 0 time = 4350
.meas tran vdout0_0ck86 FIND v(dout0_0) AT=4350.25n

* CHECK dout0_1 Vdout0_1ck86 = 0 time = 4350
.meas tran vdout0_1ck86 FIND v(dout0_1) AT=4350.25n

* CHECK dout0_2 Vdout0_2ck86 = 0 time = 4350
.meas tran vdout0_2ck86 FIND v(dout0_2) AT=4350.25n

* CHECK dout0_3 Vdout0_3ck86 = 1.8 time = 4350
.meas tran vdout0_3ck86 FIND v(dout0_3) AT=4350.25n

* CHECK dout0_4 Vdout0_4ck86 = 1.8 time = 4350
.meas tran vdout0_4ck86 FIND v(dout0_4) AT=4350.25n

* CHECK dout0_5 Vdout0_5ck86 = 1.8 time = 4350
.meas tran vdout0_5ck86 FIND v(dout0_5) AT=4350.25n

* CHECK dout0_6 Vdout0_6ck86 = 1.8 time = 4350
.meas tran vdout0_6ck86 FIND v(dout0_6) AT=4350.25n

* CHECK dout0_7 Vdout0_7ck86 = 0 time = 4350
.meas tran vdout0_7ck86 FIND v(dout0_7) AT=4350.25n

* CHECK dout0_8 Vdout0_8ck86 = 0 time = 4350
.meas tran vdout0_8ck86 FIND v(dout0_8) AT=4350.25n

* CHECK dout0_9 Vdout0_9ck86 = 1.8 time = 4350
.meas tran vdout0_9ck86 FIND v(dout0_9) AT=4350.25n

* CHECK dout0_10 Vdout0_10ck86 = 1.8 time = 4350
.meas tran vdout0_10ck86 FIND v(dout0_10) AT=4350.25n

* CHECK dout0_11 Vdout0_11ck86 = 0 time = 4350
.meas tran vdout0_11ck86 FIND v(dout0_11) AT=4350.25n

* CHECK dout0_12 Vdout0_12ck86 = 0 time = 4350
.meas tran vdout0_12ck86 FIND v(dout0_12) AT=4350.25n

* CHECK dout0_13 Vdout0_13ck86 = 1.8 time = 4350
.meas tran vdout0_13ck86 FIND v(dout0_13) AT=4350.25n

* CHECK dout0_14 Vdout0_14ck86 = 1.8 time = 4350
.meas tran vdout0_14ck86 FIND v(dout0_14) AT=4350.25n

* CHECK dout0_15 Vdout0_15ck86 = 1.8 time = 4350
.meas tran vdout0_15ck86 FIND v(dout0_15) AT=4350.25n

* CHECK dout0_0 Vdout0_0ck87 = 0 time = 4400
.meas tran vdout0_0ck87 FIND v(dout0_0) AT=4400.25n

* CHECK dout0_1 Vdout0_1ck87 = 0 time = 4400
.meas tran vdout0_1ck87 FIND v(dout0_1) AT=4400.25n

* CHECK dout0_2 Vdout0_2ck87 = 0 time = 4400
.meas tran vdout0_2ck87 FIND v(dout0_2) AT=4400.25n

* CHECK dout0_3 Vdout0_3ck87 = 0 time = 4400
.meas tran vdout0_3ck87 FIND v(dout0_3) AT=4400.25n

* CHECK dout0_4 Vdout0_4ck87 = 1.8 time = 4400
.meas tran vdout0_4ck87 FIND v(dout0_4) AT=4400.25n

* CHECK dout0_5 Vdout0_5ck87 = 0 time = 4400
.meas tran vdout0_5ck87 FIND v(dout0_5) AT=4400.25n

* CHECK dout0_6 Vdout0_6ck87 = 0 time = 4400
.meas tran vdout0_6ck87 FIND v(dout0_6) AT=4400.25n

* CHECK dout0_7 Vdout0_7ck87 = 1.8 time = 4400
.meas tran vdout0_7ck87 FIND v(dout0_7) AT=4400.25n

* CHECK dout0_8 Vdout0_8ck87 = 0 time = 4400
.meas tran vdout0_8ck87 FIND v(dout0_8) AT=4400.25n

* CHECK dout0_9 Vdout0_9ck87 = 0 time = 4400
.meas tran vdout0_9ck87 FIND v(dout0_9) AT=4400.25n

* CHECK dout0_10 Vdout0_10ck87 = 0 time = 4400
.meas tran vdout0_10ck87 FIND v(dout0_10) AT=4400.25n

* CHECK dout0_11 Vdout0_11ck87 = 0 time = 4400
.meas tran vdout0_11ck87 FIND v(dout0_11) AT=4400.25n

* CHECK dout0_12 Vdout0_12ck87 = 1.8 time = 4400
.meas tran vdout0_12ck87 FIND v(dout0_12) AT=4400.25n

* CHECK dout0_13 Vdout0_13ck87 = 0 time = 4400
.meas tran vdout0_13ck87 FIND v(dout0_13) AT=4400.25n

* CHECK dout0_14 Vdout0_14ck87 = 0 time = 4400
.meas tran vdout0_14ck87 FIND v(dout0_14) AT=4400.25n

* CHECK dout0_15 Vdout0_15ck87 = 0 time = 4400
.meas tran vdout0_15ck87 FIND v(dout0_15) AT=4400.25n

* CHECK dout0_0 Vdout0_0ck88 = 0 time = 4450
.meas tran vdout0_0ck88 FIND v(dout0_0) AT=4450.25n

* CHECK dout0_1 Vdout0_1ck88 = 0 time = 4450
.meas tran vdout0_1ck88 FIND v(dout0_1) AT=4450.25n

* CHECK dout0_2 Vdout0_2ck88 = 1.8 time = 4450
.meas tran vdout0_2ck88 FIND v(dout0_2) AT=4450.25n

* CHECK dout0_3 Vdout0_3ck88 = 0 time = 4450
.meas tran vdout0_3ck88 FIND v(dout0_3) AT=4450.25n

* CHECK dout0_4 Vdout0_4ck88 = 0 time = 4450
.meas tran vdout0_4ck88 FIND v(dout0_4) AT=4450.25n

* CHECK dout0_5 Vdout0_5ck88 = 0 time = 4450
.meas tran vdout0_5ck88 FIND v(dout0_5) AT=4450.25n

* CHECK dout0_6 Vdout0_6ck88 = 1.8 time = 4450
.meas tran vdout0_6ck88 FIND v(dout0_6) AT=4450.25n

* CHECK dout0_7 Vdout0_7ck88 = 0 time = 4450
.meas tran vdout0_7ck88 FIND v(dout0_7) AT=4450.25n

* CHECK dout0_8 Vdout0_8ck88 = 0 time = 4450
.meas tran vdout0_8ck88 FIND v(dout0_8) AT=4450.25n

* CHECK dout0_9 Vdout0_9ck88 = 0 time = 4450
.meas tran vdout0_9ck88 FIND v(dout0_9) AT=4450.25n

* CHECK dout0_10 Vdout0_10ck88 = 0 time = 4450
.meas tran vdout0_10ck88 FIND v(dout0_10) AT=4450.25n

* CHECK dout0_11 Vdout0_11ck88 = 0 time = 4450
.meas tran vdout0_11ck88 FIND v(dout0_11) AT=4450.25n

* CHECK dout0_12 Vdout0_12ck88 = 1.8 time = 4450
.meas tran vdout0_12ck88 FIND v(dout0_12) AT=4450.25n

* CHECK dout0_13 Vdout0_13ck88 = 1.8 time = 4450
.meas tran vdout0_13ck88 FIND v(dout0_13) AT=4450.25n

* CHECK dout0_14 Vdout0_14ck88 = 1.8 time = 4450
.meas tran vdout0_14ck88 FIND v(dout0_14) AT=4450.25n

* CHECK dout0_15 Vdout0_15ck88 = 0 time = 4450
.meas tran vdout0_15ck88 FIND v(dout0_15) AT=4450.25n

* CHECK dout0_0 Vdout0_0ck91 = 0 time = 4600
.meas tran vdout0_0ck91 FIND v(dout0_0) AT=4600.25n

* CHECK dout0_1 Vdout0_1ck91 = 0 time = 4600
.meas tran vdout0_1ck91 FIND v(dout0_1) AT=4600.25n

* CHECK dout0_2 Vdout0_2ck91 = 0 time = 4600
.meas tran vdout0_2ck91 FIND v(dout0_2) AT=4600.25n

* CHECK dout0_3 Vdout0_3ck91 = 1.8 time = 4600
.meas tran vdout0_3ck91 FIND v(dout0_3) AT=4600.25n

* CHECK dout0_4 Vdout0_4ck91 = 0 time = 4600
.meas tran vdout0_4ck91 FIND v(dout0_4) AT=4600.25n

* CHECK dout0_5 Vdout0_5ck91 = 0 time = 4600
.meas tran vdout0_5ck91 FIND v(dout0_5) AT=4600.25n

* CHECK dout0_6 Vdout0_6ck91 = 1.8 time = 4600
.meas tran vdout0_6ck91 FIND v(dout0_6) AT=4600.25n

* CHECK dout0_7 Vdout0_7ck91 = 1.8 time = 4600
.meas tran vdout0_7ck91 FIND v(dout0_7) AT=4600.25n

* CHECK dout0_8 Vdout0_8ck91 = 0 time = 4600
.meas tran vdout0_8ck91 FIND v(dout0_8) AT=4600.25n

* CHECK dout0_9 Vdout0_9ck91 = 0 time = 4600
.meas tran vdout0_9ck91 FIND v(dout0_9) AT=4600.25n

* CHECK dout0_10 Vdout0_10ck91 = 0 time = 4600
.meas tran vdout0_10ck91 FIND v(dout0_10) AT=4600.25n

* CHECK dout0_11 Vdout0_11ck91 = 0 time = 4600
.meas tran vdout0_11ck91 FIND v(dout0_11) AT=4600.25n

* CHECK dout0_12 Vdout0_12ck91 = 1.8 time = 4600
.meas tran vdout0_12ck91 FIND v(dout0_12) AT=4600.25n

* CHECK dout0_13 Vdout0_13ck91 = 1.8 time = 4600
.meas tran vdout0_13ck91 FIND v(dout0_13) AT=4600.25n

* CHECK dout0_14 Vdout0_14ck91 = 1.8 time = 4600
.meas tran vdout0_14ck91 FIND v(dout0_14) AT=4600.25n

* CHECK dout0_15 Vdout0_15ck91 = 1.8 time = 4600
.meas tran vdout0_15ck91 FIND v(dout0_15) AT=4600.25n

* CHECK dout0_0 Vdout0_0ck93 = 0 time = 4700
.meas tran vdout0_0ck93 FIND v(dout0_0) AT=4700.25n

* CHECK dout0_1 Vdout0_1ck93 = 0 time = 4700
.meas tran vdout0_1ck93 FIND v(dout0_1) AT=4700.25n

* CHECK dout0_2 Vdout0_2ck93 = 1.8 time = 4700
.meas tran vdout0_2ck93 FIND v(dout0_2) AT=4700.25n

* CHECK dout0_3 Vdout0_3ck93 = 1.8 time = 4700
.meas tran vdout0_3ck93 FIND v(dout0_3) AT=4700.25n

* CHECK dout0_4 Vdout0_4ck93 = 0 time = 4700
.meas tran vdout0_4ck93 FIND v(dout0_4) AT=4700.25n

* CHECK dout0_5 Vdout0_5ck93 = 0 time = 4700
.meas tran vdout0_5ck93 FIND v(dout0_5) AT=4700.25n

* CHECK dout0_6 Vdout0_6ck93 = 1.8 time = 4700
.meas tran vdout0_6ck93 FIND v(dout0_6) AT=4700.25n

* CHECK dout0_7 Vdout0_7ck93 = 0 time = 4700
.meas tran vdout0_7ck93 FIND v(dout0_7) AT=4700.25n

* CHECK dout0_8 Vdout0_8ck93 = 1.8 time = 4700
.meas tran vdout0_8ck93 FIND v(dout0_8) AT=4700.25n

* CHECK dout0_9 Vdout0_9ck93 = 1.8 time = 4700
.meas tran vdout0_9ck93 FIND v(dout0_9) AT=4700.25n

* CHECK dout0_10 Vdout0_10ck93 = 0 time = 4700
.meas tran vdout0_10ck93 FIND v(dout0_10) AT=4700.25n

* CHECK dout0_11 Vdout0_11ck93 = 0 time = 4700
.meas tran vdout0_11ck93 FIND v(dout0_11) AT=4700.25n

* CHECK dout0_12 Vdout0_12ck93 = 0 time = 4700
.meas tran vdout0_12ck93 FIND v(dout0_12) AT=4700.25n

* CHECK dout0_13 Vdout0_13ck93 = 1.8 time = 4700
.meas tran vdout0_13ck93 FIND v(dout0_13) AT=4700.25n

* CHECK dout0_14 Vdout0_14ck93 = 1.8 time = 4700
.meas tran vdout0_14ck93 FIND v(dout0_14) AT=4700.25n

* CHECK dout0_15 Vdout0_15ck93 = 1.8 time = 4700
.meas tran vdout0_15ck93 FIND v(dout0_15) AT=4700.25n

* CHECK dout0_0 Vdout0_0ck94 = 0 time = 4750
.meas tran vdout0_0ck94 FIND v(dout0_0) AT=4750.25n

* CHECK dout0_1 Vdout0_1ck94 = 0 time = 4750
.meas tran vdout0_1ck94 FIND v(dout0_1) AT=4750.25n

* CHECK dout0_2 Vdout0_2ck94 = 0 time = 4750
.meas tran vdout0_2ck94 FIND v(dout0_2) AT=4750.25n

* CHECK dout0_3 Vdout0_3ck94 = 0 time = 4750
.meas tran vdout0_3ck94 FIND v(dout0_3) AT=4750.25n

* CHECK dout0_4 Vdout0_4ck94 = 0 time = 4750
.meas tran vdout0_4ck94 FIND v(dout0_4) AT=4750.25n

* CHECK dout0_5 Vdout0_5ck94 = 1.8 time = 4750
.meas tran vdout0_5ck94 FIND v(dout0_5) AT=4750.25n

* CHECK dout0_6 Vdout0_6ck94 = 0 time = 4750
.meas tran vdout0_6ck94 FIND v(dout0_6) AT=4750.25n

* CHECK dout0_7 Vdout0_7ck94 = 1.8 time = 4750
.meas tran vdout0_7ck94 FIND v(dout0_7) AT=4750.25n

* CHECK dout0_8 Vdout0_8ck94 = 0 time = 4750
.meas tran vdout0_8ck94 FIND v(dout0_8) AT=4750.25n

* CHECK dout0_9 Vdout0_9ck94 = 1.8 time = 4750
.meas tran vdout0_9ck94 FIND v(dout0_9) AT=4750.25n

* CHECK dout0_10 Vdout0_10ck94 = 1.8 time = 4750
.meas tran vdout0_10ck94 FIND v(dout0_10) AT=4750.25n

* CHECK dout0_11 Vdout0_11ck94 = 0 time = 4750
.meas tran vdout0_11ck94 FIND v(dout0_11) AT=4750.25n

* CHECK dout0_12 Vdout0_12ck94 = 0 time = 4750
.meas tran vdout0_12ck94 FIND v(dout0_12) AT=4750.25n

* CHECK dout0_13 Vdout0_13ck94 = 1.8 time = 4750
.meas tran vdout0_13ck94 FIND v(dout0_13) AT=4750.25n

* CHECK dout0_14 Vdout0_14ck94 = 1.8 time = 4750
.meas tran vdout0_14ck94 FIND v(dout0_14) AT=4750.25n

* CHECK dout0_15 Vdout0_15ck94 = 0 time = 4750
.meas tran vdout0_15ck94 FIND v(dout0_15) AT=4750.25n

* CHECK dout0_0 Vdout0_0ck99 = 0 time = 5000
.meas tran vdout0_0ck99 FIND v(dout0_0) AT=5000.25n

* CHECK dout0_1 Vdout0_1ck99 = 0 time = 5000
.meas tran vdout0_1ck99 FIND v(dout0_1) AT=5000.25n

* CHECK dout0_2 Vdout0_2ck99 = 0 time = 5000
.meas tran vdout0_2ck99 FIND v(dout0_2) AT=5000.25n

* CHECK dout0_3 Vdout0_3ck99 = 0 time = 5000
.meas tran vdout0_3ck99 FIND v(dout0_3) AT=5000.25n

* CHECK dout0_4 Vdout0_4ck99 = 0 time = 5000
.meas tran vdout0_4ck99 FIND v(dout0_4) AT=5000.25n

* CHECK dout0_5 Vdout0_5ck99 = 1.8 time = 5000
.meas tran vdout0_5ck99 FIND v(dout0_5) AT=5000.25n

* CHECK dout0_6 Vdout0_6ck99 = 0 time = 5000
.meas tran vdout0_6ck99 FIND v(dout0_6) AT=5000.25n

* CHECK dout0_7 Vdout0_7ck99 = 1.8 time = 5000
.meas tran vdout0_7ck99 FIND v(dout0_7) AT=5000.25n

* CHECK dout0_8 Vdout0_8ck99 = 0 time = 5000
.meas tran vdout0_8ck99 FIND v(dout0_8) AT=5000.25n

* CHECK dout0_9 Vdout0_9ck99 = 1.8 time = 5000
.meas tran vdout0_9ck99 FIND v(dout0_9) AT=5000.25n

* CHECK dout0_10 Vdout0_10ck99 = 1.8 time = 5000
.meas tran vdout0_10ck99 FIND v(dout0_10) AT=5000.25n

* CHECK dout0_11 Vdout0_11ck99 = 0 time = 5000
.meas tran vdout0_11ck99 FIND v(dout0_11) AT=5000.25n

* CHECK dout0_12 Vdout0_12ck99 = 0 time = 5000
.meas tran vdout0_12ck99 FIND v(dout0_12) AT=5000.25n

* CHECK dout0_13 Vdout0_13ck99 = 1.8 time = 5000
.meas tran vdout0_13ck99 FIND v(dout0_13) AT=5000.25n

* CHECK dout0_14 Vdout0_14ck99 = 1.8 time = 5000
.meas tran vdout0_14ck99 FIND v(dout0_14) AT=5000.25n

* CHECK dout0_15 Vdout0_15ck99 = 0 time = 5000
.meas tran vdout0_15ck99 FIND v(dout0_15) AT=5000.25n

* CHECK dout0_0 Vdout0_0ck100 = 0 time = 5050
.meas tran vdout0_0ck100 FIND v(dout0_0) AT=5050.25n

* CHECK dout0_1 Vdout0_1ck100 = 0 time = 5050
.meas tran vdout0_1ck100 FIND v(dout0_1) AT=5050.25n

* CHECK dout0_2 Vdout0_2ck100 = 0 time = 5050
.meas tran vdout0_2ck100 FIND v(dout0_2) AT=5050.25n

* CHECK dout0_3 Vdout0_3ck100 = 0 time = 5050
.meas tran vdout0_3ck100 FIND v(dout0_3) AT=5050.25n

* CHECK dout0_4 Vdout0_4ck100 = 1.8 time = 5050
.meas tran vdout0_4ck100 FIND v(dout0_4) AT=5050.25n

* CHECK dout0_5 Vdout0_5ck100 = 0 time = 5050
.meas tran vdout0_5ck100 FIND v(dout0_5) AT=5050.25n

* CHECK dout0_6 Vdout0_6ck100 = 0 time = 5050
.meas tran vdout0_6ck100 FIND v(dout0_6) AT=5050.25n

* CHECK dout0_7 Vdout0_7ck100 = 1.8 time = 5050
.meas tran vdout0_7ck100 FIND v(dout0_7) AT=5050.25n

* CHECK dout0_8 Vdout0_8ck100 = 0 time = 5050
.meas tran vdout0_8ck100 FIND v(dout0_8) AT=5050.25n

* CHECK dout0_9 Vdout0_9ck100 = 0 time = 5050
.meas tran vdout0_9ck100 FIND v(dout0_9) AT=5050.25n

* CHECK dout0_10 Vdout0_10ck100 = 0 time = 5050
.meas tran vdout0_10ck100 FIND v(dout0_10) AT=5050.25n

* CHECK dout0_11 Vdout0_11ck100 = 0 time = 5050
.meas tran vdout0_11ck100 FIND v(dout0_11) AT=5050.25n

* CHECK dout0_12 Vdout0_12ck100 = 1.8 time = 5050
.meas tran vdout0_12ck100 FIND v(dout0_12) AT=5050.25n

* CHECK dout0_13 Vdout0_13ck100 = 0 time = 5050
.meas tran vdout0_13ck100 FIND v(dout0_13) AT=5050.25n

* CHECK dout0_14 Vdout0_14ck100 = 0 time = 5050
.meas tran vdout0_14ck100 FIND v(dout0_14) AT=5050.25n

* CHECK dout0_15 Vdout0_15ck100 = 0 time = 5050
.meas tran vdout0_15ck100 FIND v(dout0_15) AT=5050.25n

* CHECK dout0_0 Vdout0_0ck101 = 0 time = 5100
.meas tran vdout0_0ck101 FIND v(dout0_0) AT=5100.25n

* CHECK dout0_1 Vdout0_1ck101 = 0 time = 5100
.meas tran vdout0_1ck101 FIND v(dout0_1) AT=5100.25n

* CHECK dout0_2 Vdout0_2ck101 = 0 time = 5100
.meas tran vdout0_2ck101 FIND v(dout0_2) AT=5100.25n

* CHECK dout0_3 Vdout0_3ck101 = 1.8 time = 5100
.meas tran vdout0_3ck101 FIND v(dout0_3) AT=5100.25n

* CHECK dout0_4 Vdout0_4ck101 = 0 time = 5100
.meas tran vdout0_4ck101 FIND v(dout0_4) AT=5100.25n

* CHECK dout0_5 Vdout0_5ck101 = 0 time = 5100
.meas tran vdout0_5ck101 FIND v(dout0_5) AT=5100.25n

* CHECK dout0_6 Vdout0_6ck101 = 1.8 time = 5100
.meas tran vdout0_6ck101 FIND v(dout0_6) AT=5100.25n

* CHECK dout0_7 Vdout0_7ck101 = 1.8 time = 5100
.meas tran vdout0_7ck101 FIND v(dout0_7) AT=5100.25n

* CHECK dout0_8 Vdout0_8ck101 = 0 time = 5100
.meas tran vdout0_8ck101 FIND v(dout0_8) AT=5100.25n

* CHECK dout0_9 Vdout0_9ck101 = 0 time = 5100
.meas tran vdout0_9ck101 FIND v(dout0_9) AT=5100.25n

* CHECK dout0_10 Vdout0_10ck101 = 0 time = 5100
.meas tran vdout0_10ck101 FIND v(dout0_10) AT=5100.25n

* CHECK dout0_11 Vdout0_11ck101 = 0 time = 5100
.meas tran vdout0_11ck101 FIND v(dout0_11) AT=5100.25n

* CHECK dout0_12 Vdout0_12ck101 = 1.8 time = 5100
.meas tran vdout0_12ck101 FIND v(dout0_12) AT=5100.25n

* CHECK dout0_13 Vdout0_13ck101 = 1.8 time = 5100
.meas tran vdout0_13ck101 FIND v(dout0_13) AT=5100.25n

* CHECK dout0_14 Vdout0_14ck101 = 1.8 time = 5100
.meas tran vdout0_14ck101 FIND v(dout0_14) AT=5100.25n

* CHECK dout0_15 Vdout0_15ck101 = 1.8 time = 5100
.meas tran vdout0_15ck101 FIND v(dout0_15) AT=5100.25n

* CHECK dout0_0 Vdout0_0ck103 = 1.8 time = 5200
.meas tran vdout0_0ck103 FIND v(dout0_0) AT=5200.25n

* CHECK dout0_1 Vdout0_1ck103 = 0 time = 5200
.meas tran vdout0_1ck103 FIND v(dout0_1) AT=5200.25n

* CHECK dout0_2 Vdout0_2ck103 = 1.8 time = 5200
.meas tran vdout0_2ck103 FIND v(dout0_2) AT=5200.25n

* CHECK dout0_3 Vdout0_3ck103 = 0 time = 5200
.meas tran vdout0_3ck103 FIND v(dout0_3) AT=5200.25n

* CHECK dout0_4 Vdout0_4ck103 = 0 time = 5200
.meas tran vdout0_4ck103 FIND v(dout0_4) AT=5200.25n

* CHECK dout0_5 Vdout0_5ck103 = 1.8 time = 5200
.meas tran vdout0_5ck103 FIND v(dout0_5) AT=5200.25n

* CHECK dout0_6 Vdout0_6ck103 = 0 time = 5200
.meas tran vdout0_6ck103 FIND v(dout0_6) AT=5200.25n

* CHECK dout0_7 Vdout0_7ck103 = 1.8 time = 5200
.meas tran vdout0_7ck103 FIND v(dout0_7) AT=5200.25n

* CHECK dout0_8 Vdout0_8ck103 = 1.8 time = 5200
.meas tran vdout0_8ck103 FIND v(dout0_8) AT=5200.25n

* CHECK dout0_9 Vdout0_9ck103 = 1.8 time = 5200
.meas tran vdout0_9ck103 FIND v(dout0_9) AT=5200.25n

* CHECK dout0_10 Vdout0_10ck103 = 1.8 time = 5200
.meas tran vdout0_10ck103 FIND v(dout0_10) AT=5200.25n

* CHECK dout0_11 Vdout0_11ck103 = 0 time = 5200
.meas tran vdout0_11ck103 FIND v(dout0_11) AT=5200.25n

* CHECK dout0_12 Vdout0_12ck103 = 0 time = 5200
.meas tran vdout0_12ck103 FIND v(dout0_12) AT=5200.25n

* CHECK dout0_13 Vdout0_13ck103 = 0 time = 5200
.meas tran vdout0_13ck103 FIND v(dout0_13) AT=5200.25n

* CHECK dout0_14 Vdout0_14ck103 = 0 time = 5200
.meas tran vdout0_14ck103 FIND v(dout0_14) AT=5200.25n

* CHECK dout0_15 Vdout0_15ck103 = 1.8 time = 5200
.meas tran vdout0_15ck103 FIND v(dout0_15) AT=5200.25n

* CHECK dout0_0 Vdout0_0ck105 = 0 time = 5300
.meas tran vdout0_0ck105 FIND v(dout0_0) AT=5300.25n

* CHECK dout0_1 Vdout0_1ck105 = 0 time = 5300
.meas tran vdout0_1ck105 FIND v(dout0_1) AT=5300.25n

* CHECK dout0_2 Vdout0_2ck105 = 0 time = 5300
.meas tran vdout0_2ck105 FIND v(dout0_2) AT=5300.25n

* CHECK dout0_3 Vdout0_3ck105 = 1.8 time = 5300
.meas tran vdout0_3ck105 FIND v(dout0_3) AT=5300.25n

* CHECK dout0_4 Vdout0_4ck105 = 0 time = 5300
.meas tran vdout0_4ck105 FIND v(dout0_4) AT=5300.25n

* CHECK dout0_5 Vdout0_5ck105 = 0 time = 5300
.meas tran vdout0_5ck105 FIND v(dout0_5) AT=5300.25n

* CHECK dout0_6 Vdout0_6ck105 = 1.8 time = 5300
.meas tran vdout0_6ck105 FIND v(dout0_6) AT=5300.25n

* CHECK dout0_7 Vdout0_7ck105 = 1.8 time = 5300
.meas tran vdout0_7ck105 FIND v(dout0_7) AT=5300.25n

* CHECK dout0_8 Vdout0_8ck105 = 0 time = 5300
.meas tran vdout0_8ck105 FIND v(dout0_8) AT=5300.25n

* CHECK dout0_9 Vdout0_9ck105 = 0 time = 5300
.meas tran vdout0_9ck105 FIND v(dout0_9) AT=5300.25n

* CHECK dout0_10 Vdout0_10ck105 = 0 time = 5300
.meas tran vdout0_10ck105 FIND v(dout0_10) AT=5300.25n

* CHECK dout0_11 Vdout0_11ck105 = 0 time = 5300
.meas tran vdout0_11ck105 FIND v(dout0_11) AT=5300.25n

* CHECK dout0_12 Vdout0_12ck105 = 1.8 time = 5300
.meas tran vdout0_12ck105 FIND v(dout0_12) AT=5300.25n

* CHECK dout0_13 Vdout0_13ck105 = 1.8 time = 5300
.meas tran vdout0_13ck105 FIND v(dout0_13) AT=5300.25n

* CHECK dout0_14 Vdout0_14ck105 = 1.8 time = 5300
.meas tran vdout0_14ck105 FIND v(dout0_14) AT=5300.25n

* CHECK dout0_15 Vdout0_15ck105 = 1.8 time = 5300
.meas tran vdout0_15ck105 FIND v(dout0_15) AT=5300.25n

* CHECK dout0_0 Vdout0_0ck107 = 1.8 time = 5400
.meas tran vdout0_0ck107 FIND v(dout0_0) AT=5400.25n

* CHECK dout0_1 Vdout0_1ck107 = 0 time = 5400
.meas tran vdout0_1ck107 FIND v(dout0_1) AT=5400.25n

* CHECK dout0_2 Vdout0_2ck107 = 1.8 time = 5400
.meas tran vdout0_2ck107 FIND v(dout0_2) AT=5400.25n

* CHECK dout0_3 Vdout0_3ck107 = 0 time = 5400
.meas tran vdout0_3ck107 FIND v(dout0_3) AT=5400.25n

* CHECK dout0_4 Vdout0_4ck107 = 1.8 time = 5400
.meas tran vdout0_4ck107 FIND v(dout0_4) AT=5400.25n

* CHECK dout0_5 Vdout0_5ck107 = 0 time = 5400
.meas tran vdout0_5ck107 FIND v(dout0_5) AT=5400.25n

* CHECK dout0_6 Vdout0_6ck107 = 0 time = 5400
.meas tran vdout0_6ck107 FIND v(dout0_6) AT=5400.25n

* CHECK dout0_7 Vdout0_7ck107 = 1.8 time = 5400
.meas tran vdout0_7ck107 FIND v(dout0_7) AT=5400.25n

* CHECK dout0_8 Vdout0_8ck107 = 0 time = 5400
.meas tran vdout0_8ck107 FIND v(dout0_8) AT=5400.25n

* CHECK dout0_9 Vdout0_9ck107 = 1.8 time = 5400
.meas tran vdout0_9ck107 FIND v(dout0_9) AT=5400.25n

* CHECK dout0_10 Vdout0_10ck107 = 1.8 time = 5400
.meas tran vdout0_10ck107 FIND v(dout0_10) AT=5400.25n

* CHECK dout0_11 Vdout0_11ck107 = 1.8 time = 5400
.meas tran vdout0_11ck107 FIND v(dout0_11) AT=5400.25n

* CHECK dout0_12 Vdout0_12ck107 = 0 time = 5400
.meas tran vdout0_12ck107 FIND v(dout0_12) AT=5400.25n

* CHECK dout0_13 Vdout0_13ck107 = 0 time = 5400
.meas tran vdout0_13ck107 FIND v(dout0_13) AT=5400.25n

* CHECK dout0_14 Vdout0_14ck107 = 1.8 time = 5400
.meas tran vdout0_14ck107 FIND v(dout0_14) AT=5400.25n

* CHECK dout0_15 Vdout0_15ck107 = 0 time = 5400
.meas tran vdout0_15ck107 FIND v(dout0_15) AT=5400.25n

* CHECK dout0_0 Vdout0_0ck109 = 0 time = 5500
.meas tran vdout0_0ck109 FIND v(dout0_0) AT=5500.25n

* CHECK dout0_1 Vdout0_1ck109 = 0 time = 5500
.meas tran vdout0_1ck109 FIND v(dout0_1) AT=5500.25n

* CHECK dout0_2 Vdout0_2ck109 = 0 time = 5500
.meas tran vdout0_2ck109 FIND v(dout0_2) AT=5500.25n

* CHECK dout0_3 Vdout0_3ck109 = 0 time = 5500
.meas tran vdout0_3ck109 FIND v(dout0_3) AT=5500.25n

* CHECK dout0_4 Vdout0_4ck109 = 0 time = 5500
.meas tran vdout0_4ck109 FIND v(dout0_4) AT=5500.25n

* CHECK dout0_5 Vdout0_5ck109 = 1.8 time = 5500
.meas tran vdout0_5ck109 FIND v(dout0_5) AT=5500.25n

* CHECK dout0_6 Vdout0_6ck109 = 0 time = 5500
.meas tran vdout0_6ck109 FIND v(dout0_6) AT=5500.25n

* CHECK dout0_7 Vdout0_7ck109 = 1.8 time = 5500
.meas tran vdout0_7ck109 FIND v(dout0_7) AT=5500.25n

* CHECK dout0_8 Vdout0_8ck109 = 0 time = 5500
.meas tran vdout0_8ck109 FIND v(dout0_8) AT=5500.25n

* CHECK dout0_9 Vdout0_9ck109 = 1.8 time = 5500
.meas tran vdout0_9ck109 FIND v(dout0_9) AT=5500.25n

* CHECK dout0_10 Vdout0_10ck109 = 1.8 time = 5500
.meas tran vdout0_10ck109 FIND v(dout0_10) AT=5500.25n

* CHECK dout0_11 Vdout0_11ck109 = 0 time = 5500
.meas tran vdout0_11ck109 FIND v(dout0_11) AT=5500.25n

* CHECK dout0_12 Vdout0_12ck109 = 0 time = 5500
.meas tran vdout0_12ck109 FIND v(dout0_12) AT=5500.25n

* CHECK dout0_13 Vdout0_13ck109 = 1.8 time = 5500
.meas tran vdout0_13ck109 FIND v(dout0_13) AT=5500.25n

* CHECK dout0_14 Vdout0_14ck109 = 1.8 time = 5500
.meas tran vdout0_14ck109 FIND v(dout0_14) AT=5500.25n

* CHECK dout0_15 Vdout0_15ck109 = 0 time = 5500
.meas tran vdout0_15ck109 FIND v(dout0_15) AT=5500.25n

* CHECK dout0_0 Vdout0_0ck111 = 0 time = 5600
.meas tran vdout0_0ck111 FIND v(dout0_0) AT=5600.25n

* CHECK dout0_1 Vdout0_1ck111 = 0 time = 5600
.meas tran vdout0_1ck111 FIND v(dout0_1) AT=5600.25n

* CHECK dout0_2 Vdout0_2ck111 = 0 time = 5600
.meas tran vdout0_2ck111 FIND v(dout0_2) AT=5600.25n

* CHECK dout0_3 Vdout0_3ck111 = 0 time = 5600
.meas tran vdout0_3ck111 FIND v(dout0_3) AT=5600.25n

* CHECK dout0_4 Vdout0_4ck111 = 1.8 time = 5600
.meas tran vdout0_4ck111 FIND v(dout0_4) AT=5600.25n

* CHECK dout0_5 Vdout0_5ck111 = 0 time = 5600
.meas tran vdout0_5ck111 FIND v(dout0_5) AT=5600.25n

* CHECK dout0_6 Vdout0_6ck111 = 0 time = 5600
.meas tran vdout0_6ck111 FIND v(dout0_6) AT=5600.25n

* CHECK dout0_7 Vdout0_7ck111 = 1.8 time = 5600
.meas tran vdout0_7ck111 FIND v(dout0_7) AT=5600.25n

* CHECK dout0_8 Vdout0_8ck111 = 0 time = 5600
.meas tran vdout0_8ck111 FIND v(dout0_8) AT=5600.25n

* CHECK dout0_9 Vdout0_9ck111 = 0 time = 5600
.meas tran vdout0_9ck111 FIND v(dout0_9) AT=5600.25n

* CHECK dout0_10 Vdout0_10ck111 = 0 time = 5600
.meas tran vdout0_10ck111 FIND v(dout0_10) AT=5600.25n

* CHECK dout0_11 Vdout0_11ck111 = 0 time = 5600
.meas tran vdout0_11ck111 FIND v(dout0_11) AT=5600.25n

* CHECK dout0_12 Vdout0_12ck111 = 1.8 time = 5600
.meas tran vdout0_12ck111 FIND v(dout0_12) AT=5600.25n

* CHECK dout0_13 Vdout0_13ck111 = 0 time = 5600
.meas tran vdout0_13ck111 FIND v(dout0_13) AT=5600.25n

* CHECK dout0_14 Vdout0_14ck111 = 0 time = 5600
.meas tran vdout0_14ck111 FIND v(dout0_14) AT=5600.25n

* CHECK dout0_15 Vdout0_15ck111 = 0 time = 5600
.meas tran vdout0_15ck111 FIND v(dout0_15) AT=5600.25n

* CHECK dout0_0 Vdout0_0ck116 = 1.8 time = 5850
.meas tran vdout0_0ck116 FIND v(dout0_0) AT=5850.25n

* CHECK dout0_1 Vdout0_1ck116 = 0 time = 5850
.meas tran vdout0_1ck116 FIND v(dout0_1) AT=5850.25n

* CHECK dout0_2 Vdout0_2ck116 = 1.8 time = 5850
.meas tran vdout0_2ck116 FIND v(dout0_2) AT=5850.25n

* CHECK dout0_3 Vdout0_3ck116 = 0 time = 5850
.meas tran vdout0_3ck116 FIND v(dout0_3) AT=5850.25n

* CHECK dout0_4 Vdout0_4ck116 = 0 time = 5850
.meas tran vdout0_4ck116 FIND v(dout0_4) AT=5850.25n

* CHECK dout0_5 Vdout0_5ck116 = 1.8 time = 5850
.meas tran vdout0_5ck116 FIND v(dout0_5) AT=5850.25n

* CHECK dout0_6 Vdout0_6ck116 = 1.8 time = 5850
.meas tran vdout0_6ck116 FIND v(dout0_6) AT=5850.25n

* CHECK dout0_7 Vdout0_7ck116 = 0 time = 5850
.meas tran vdout0_7ck116 FIND v(dout0_7) AT=5850.25n

* CHECK dout0_8 Vdout0_8ck116 = 0 time = 5850
.meas tran vdout0_8ck116 FIND v(dout0_8) AT=5850.25n

* CHECK dout0_9 Vdout0_9ck116 = 1.8 time = 5850
.meas tran vdout0_9ck116 FIND v(dout0_9) AT=5850.25n

* CHECK dout0_10 Vdout0_10ck116 = 0 time = 5850
.meas tran vdout0_10ck116 FIND v(dout0_10) AT=5850.25n

* CHECK dout0_11 Vdout0_11ck116 = 1.8 time = 5850
.meas tran vdout0_11ck116 FIND v(dout0_11) AT=5850.25n

* CHECK dout0_12 Vdout0_12ck116 = 1.8 time = 5850
.meas tran vdout0_12ck116 FIND v(dout0_12) AT=5850.25n

* CHECK dout0_13 Vdout0_13ck116 = 0 time = 5850
.meas tran vdout0_13ck116 FIND v(dout0_13) AT=5850.25n

* CHECK dout0_14 Vdout0_14ck116 = 0 time = 5850
.meas tran vdout0_14ck116 FIND v(dout0_14) AT=5850.25n

* CHECK dout0_15 Vdout0_15ck116 = 1.8 time = 5850
.meas tran vdout0_15ck116 FIND v(dout0_15) AT=5850.25n

* CHECK dout0_0 Vdout0_0ck118 = 0 time = 5950
.meas tran vdout0_0ck118 FIND v(dout0_0) AT=5950.25n

* CHECK dout0_1 Vdout0_1ck118 = 0 time = 5950
.meas tran vdout0_1ck118 FIND v(dout0_1) AT=5950.25n

* CHECK dout0_2 Vdout0_2ck118 = 0 time = 5950
.meas tran vdout0_2ck118 FIND v(dout0_2) AT=5950.25n

* CHECK dout0_3 Vdout0_3ck118 = 1.8 time = 5950
.meas tran vdout0_3ck118 FIND v(dout0_3) AT=5950.25n

* CHECK dout0_4 Vdout0_4ck118 = 0 time = 5950
.meas tran vdout0_4ck118 FIND v(dout0_4) AT=5950.25n

* CHECK dout0_5 Vdout0_5ck118 = 1.8 time = 5950
.meas tran vdout0_5ck118 FIND v(dout0_5) AT=5950.25n

* CHECK dout0_6 Vdout0_6ck118 = 1.8 time = 5950
.meas tran vdout0_6ck118 FIND v(dout0_6) AT=5950.25n

* CHECK dout0_7 Vdout0_7ck118 = 1.8 time = 5950
.meas tran vdout0_7ck118 FIND v(dout0_7) AT=5950.25n

* CHECK dout0_8 Vdout0_8ck118 = 1.8 time = 5950
.meas tran vdout0_8ck118 FIND v(dout0_8) AT=5950.25n

* CHECK dout0_9 Vdout0_9ck118 = 0 time = 5950
.meas tran vdout0_9ck118 FIND v(dout0_9) AT=5950.25n

* CHECK dout0_10 Vdout0_10ck118 = 1.8 time = 5950
.meas tran vdout0_10ck118 FIND v(dout0_10) AT=5950.25n

* CHECK dout0_11 Vdout0_11ck118 = 1.8 time = 5950
.meas tran vdout0_11ck118 FIND v(dout0_11) AT=5950.25n

* CHECK dout0_12 Vdout0_12ck118 = 0 time = 5950
.meas tran vdout0_12ck118 FIND v(dout0_12) AT=5950.25n

* CHECK dout0_13 Vdout0_13ck118 = 1.8 time = 5950
.meas tran vdout0_13ck118 FIND v(dout0_13) AT=5950.25n

* CHECK dout0_14 Vdout0_14ck118 = 1.8 time = 5950
.meas tran vdout0_14ck118 FIND v(dout0_14) AT=5950.25n

* CHECK dout0_15 Vdout0_15ck118 = 0 time = 5950
.meas tran vdout0_15ck118 FIND v(dout0_15) AT=5950.25n

* CHECK dout0_0 Vdout0_0ck121 = 1.8 time = 6100
.meas tran vdout0_0ck121 FIND v(dout0_0) AT=6100.25n

* CHECK dout0_1 Vdout0_1ck121 = 0 time = 6100
.meas tran vdout0_1ck121 FIND v(dout0_1) AT=6100.25n

* CHECK dout0_2 Vdout0_2ck121 = 1.8 time = 6100
.meas tran vdout0_2ck121 FIND v(dout0_2) AT=6100.25n

* CHECK dout0_3 Vdout0_3ck121 = 0 time = 6100
.meas tran vdout0_3ck121 FIND v(dout0_3) AT=6100.25n

* CHECK dout0_4 Vdout0_4ck121 = 0 time = 6100
.meas tran vdout0_4ck121 FIND v(dout0_4) AT=6100.25n

* CHECK dout0_5 Vdout0_5ck121 = 1.8 time = 6100
.meas tran vdout0_5ck121 FIND v(dout0_5) AT=6100.25n

* CHECK dout0_6 Vdout0_6ck121 = 1.8 time = 6100
.meas tran vdout0_6ck121 FIND v(dout0_6) AT=6100.25n

* CHECK dout0_7 Vdout0_7ck121 = 0 time = 6100
.meas tran vdout0_7ck121 FIND v(dout0_7) AT=6100.25n

* CHECK dout0_8 Vdout0_8ck121 = 0 time = 6100
.meas tran vdout0_8ck121 FIND v(dout0_8) AT=6100.25n

* CHECK dout0_9 Vdout0_9ck121 = 1.8 time = 6100
.meas tran vdout0_9ck121 FIND v(dout0_9) AT=6100.25n

* CHECK dout0_10 Vdout0_10ck121 = 0 time = 6100
.meas tran vdout0_10ck121 FIND v(dout0_10) AT=6100.25n

* CHECK dout0_11 Vdout0_11ck121 = 1.8 time = 6100
.meas tran vdout0_11ck121 FIND v(dout0_11) AT=6100.25n

* CHECK dout0_12 Vdout0_12ck121 = 1.8 time = 6100
.meas tran vdout0_12ck121 FIND v(dout0_12) AT=6100.25n

* CHECK dout0_13 Vdout0_13ck121 = 0 time = 6100
.meas tran vdout0_13ck121 FIND v(dout0_13) AT=6100.25n

* CHECK dout0_14 Vdout0_14ck121 = 0 time = 6100
.meas tran vdout0_14ck121 FIND v(dout0_14) AT=6100.25n

* CHECK dout0_15 Vdout0_15ck121 = 1.8 time = 6100
.meas tran vdout0_15ck121 FIND v(dout0_15) AT=6100.25n

* CHECK dout0_0 Vdout0_0ck123 = 1.8 time = 6200
.meas tran vdout0_0ck123 FIND v(dout0_0) AT=6200.25n

* CHECK dout0_1 Vdout0_1ck123 = 0 time = 6200
.meas tran vdout0_1ck123 FIND v(dout0_1) AT=6200.25n

* CHECK dout0_2 Vdout0_2ck123 = 0 time = 6200
.meas tran vdout0_2ck123 FIND v(dout0_2) AT=6200.25n

* CHECK dout0_3 Vdout0_3ck123 = 1.8 time = 6200
.meas tran vdout0_3ck123 FIND v(dout0_3) AT=6200.25n

* CHECK dout0_4 Vdout0_4ck123 = 1.8 time = 6200
.meas tran vdout0_4ck123 FIND v(dout0_4) AT=6200.25n

* CHECK dout0_5 Vdout0_5ck123 = 1.8 time = 6200
.meas tran vdout0_5ck123 FIND v(dout0_5) AT=6200.25n

* CHECK dout0_6 Vdout0_6ck123 = 1.8 time = 6200
.meas tran vdout0_6ck123 FIND v(dout0_6) AT=6200.25n

* CHECK dout0_7 Vdout0_7ck123 = 0 time = 6200
.meas tran vdout0_7ck123 FIND v(dout0_7) AT=6200.25n

* CHECK dout0_8 Vdout0_8ck123 = 0 time = 6200
.meas tran vdout0_8ck123 FIND v(dout0_8) AT=6200.25n

* CHECK dout0_9 Vdout0_9ck123 = 1.8 time = 6200
.meas tran vdout0_9ck123 FIND v(dout0_9) AT=6200.25n

* CHECK dout0_10 Vdout0_10ck123 = 1.8 time = 6200
.meas tran vdout0_10ck123 FIND v(dout0_10) AT=6200.25n

* CHECK dout0_11 Vdout0_11ck123 = 0 time = 6200
.meas tran vdout0_11ck123 FIND v(dout0_11) AT=6200.25n

* CHECK dout0_12 Vdout0_12ck123 = 1.8 time = 6200
.meas tran vdout0_12ck123 FIND v(dout0_12) AT=6200.25n

* CHECK dout0_13 Vdout0_13ck123 = 0 time = 6200
.meas tran vdout0_13ck123 FIND v(dout0_13) AT=6200.25n

* CHECK dout0_14 Vdout0_14ck123 = 0 time = 6200
.meas tran vdout0_14ck123 FIND v(dout0_14) AT=6200.25n

* CHECK dout0_15 Vdout0_15ck123 = 0 time = 6200
.meas tran vdout0_15ck123 FIND v(dout0_15) AT=6200.25n

* CHECK dout0_0 Vdout0_0ck124 = 0 time = 6250
.meas tran vdout0_0ck124 FIND v(dout0_0) AT=6250.25n

* CHECK dout0_1 Vdout0_1ck124 = 0 time = 6250
.meas tran vdout0_1ck124 FIND v(dout0_1) AT=6250.25n

* CHECK dout0_2 Vdout0_2ck124 = 1.8 time = 6250
.meas tran vdout0_2ck124 FIND v(dout0_2) AT=6250.25n

* CHECK dout0_3 Vdout0_3ck124 = 0 time = 6250
.meas tran vdout0_3ck124 FIND v(dout0_3) AT=6250.25n

* CHECK dout0_4 Vdout0_4ck124 = 0 time = 6250
.meas tran vdout0_4ck124 FIND v(dout0_4) AT=6250.25n

* CHECK dout0_5 Vdout0_5ck124 = 1.8 time = 6250
.meas tran vdout0_5ck124 FIND v(dout0_5) AT=6250.25n

* CHECK dout0_6 Vdout0_6ck124 = 0 time = 6250
.meas tran vdout0_6ck124 FIND v(dout0_6) AT=6250.25n

* CHECK dout0_7 Vdout0_7ck124 = 1.8 time = 6250
.meas tran vdout0_7ck124 FIND v(dout0_7) AT=6250.25n

* CHECK dout0_8 Vdout0_8ck124 = 1.8 time = 6250
.meas tran vdout0_8ck124 FIND v(dout0_8) AT=6250.25n

* CHECK dout0_9 Vdout0_9ck124 = 1.8 time = 6250
.meas tran vdout0_9ck124 FIND v(dout0_9) AT=6250.25n

* CHECK dout0_10 Vdout0_10ck124 = 1.8 time = 6250
.meas tran vdout0_10ck124 FIND v(dout0_10) AT=6250.25n

* CHECK dout0_11 Vdout0_11ck124 = 1.8 time = 6250
.meas tran vdout0_11ck124 FIND v(dout0_11) AT=6250.25n

* CHECK dout0_12 Vdout0_12ck124 = 0 time = 6250
.meas tran vdout0_12ck124 FIND v(dout0_12) AT=6250.25n

* CHECK dout0_13 Vdout0_13ck124 = 0 time = 6250
.meas tran vdout0_13ck124 FIND v(dout0_13) AT=6250.25n

* CHECK dout0_14 Vdout0_14ck124 = 0 time = 6250
.meas tran vdout0_14ck124 FIND v(dout0_14) AT=6250.25n

* CHECK dout0_15 Vdout0_15ck124 = 1.8 time = 6250
.meas tran vdout0_15ck124 FIND v(dout0_15) AT=6250.25n

* CHECK dout0_0 Vdout0_0ck125 = 1.8 time = 6300
.meas tran vdout0_0ck125 FIND v(dout0_0) AT=6300.25n

* CHECK dout0_1 Vdout0_1ck125 = 1.8 time = 6300
.meas tran vdout0_1ck125 FIND v(dout0_1) AT=6300.25n

* CHECK dout0_2 Vdout0_2ck125 = 0 time = 6300
.meas tran vdout0_2ck125 FIND v(dout0_2) AT=6300.25n

* CHECK dout0_3 Vdout0_3ck125 = 1.8 time = 6300
.meas tran vdout0_3ck125 FIND v(dout0_3) AT=6300.25n

* CHECK dout0_4 Vdout0_4ck125 = 0 time = 6300
.meas tran vdout0_4ck125 FIND v(dout0_4) AT=6300.25n

* CHECK dout0_5 Vdout0_5ck125 = 1.8 time = 6300
.meas tran vdout0_5ck125 FIND v(dout0_5) AT=6300.25n

* CHECK dout0_6 Vdout0_6ck125 = 0 time = 6300
.meas tran vdout0_6ck125 FIND v(dout0_6) AT=6300.25n

* CHECK dout0_7 Vdout0_7ck125 = 1.8 time = 6300
.meas tran vdout0_7ck125 FIND v(dout0_7) AT=6300.25n

* CHECK dout0_8 Vdout0_8ck125 = 1.8 time = 6300
.meas tran vdout0_8ck125 FIND v(dout0_8) AT=6300.25n

* CHECK dout0_9 Vdout0_9ck125 = 0 time = 6300
.meas tran vdout0_9ck125 FIND v(dout0_9) AT=6300.25n

* CHECK dout0_10 Vdout0_10ck125 = 0 time = 6300
.meas tran vdout0_10ck125 FIND v(dout0_10) AT=6300.25n

* CHECK dout0_11 Vdout0_11ck125 = 0 time = 6300
.meas tran vdout0_11ck125 FIND v(dout0_11) AT=6300.25n

* CHECK dout0_12 Vdout0_12ck125 = 1.8 time = 6300
.meas tran vdout0_12ck125 FIND v(dout0_12) AT=6300.25n

* CHECK dout0_13 Vdout0_13ck125 = 0 time = 6300
.meas tran vdout0_13ck125 FIND v(dout0_13) AT=6300.25n

* CHECK dout0_14 Vdout0_14ck125 = 1.8 time = 6300
.meas tran vdout0_14ck125 FIND v(dout0_14) AT=6300.25n

* CHECK dout0_15 Vdout0_15ck125 = 0 time = 6300
.meas tran vdout0_15ck125 FIND v(dout0_15) AT=6300.25n

* CHECK dout0_0 Vdout0_0ck126 = 1.8 time = 6350
.meas tran vdout0_0ck126 FIND v(dout0_0) AT=6350.25n

* CHECK dout0_1 Vdout0_1ck126 = 0 time = 6350
.meas tran vdout0_1ck126 FIND v(dout0_1) AT=6350.25n

* CHECK dout0_2 Vdout0_2ck126 = 0 time = 6350
.meas tran vdout0_2ck126 FIND v(dout0_2) AT=6350.25n

* CHECK dout0_3 Vdout0_3ck126 = 1.8 time = 6350
.meas tran vdout0_3ck126 FIND v(dout0_3) AT=6350.25n

* CHECK dout0_4 Vdout0_4ck126 = 1.8 time = 6350
.meas tran vdout0_4ck126 FIND v(dout0_4) AT=6350.25n

* CHECK dout0_5 Vdout0_5ck126 = 1.8 time = 6350
.meas tran vdout0_5ck126 FIND v(dout0_5) AT=6350.25n

* CHECK dout0_6 Vdout0_6ck126 = 1.8 time = 6350
.meas tran vdout0_6ck126 FIND v(dout0_6) AT=6350.25n

* CHECK dout0_7 Vdout0_7ck126 = 0 time = 6350
.meas tran vdout0_7ck126 FIND v(dout0_7) AT=6350.25n

* CHECK dout0_8 Vdout0_8ck126 = 0 time = 6350
.meas tran vdout0_8ck126 FIND v(dout0_8) AT=6350.25n

* CHECK dout0_9 Vdout0_9ck126 = 1.8 time = 6350
.meas tran vdout0_9ck126 FIND v(dout0_9) AT=6350.25n

* CHECK dout0_10 Vdout0_10ck126 = 1.8 time = 6350
.meas tran vdout0_10ck126 FIND v(dout0_10) AT=6350.25n

* CHECK dout0_11 Vdout0_11ck126 = 0 time = 6350
.meas tran vdout0_11ck126 FIND v(dout0_11) AT=6350.25n

* CHECK dout0_12 Vdout0_12ck126 = 1.8 time = 6350
.meas tran vdout0_12ck126 FIND v(dout0_12) AT=6350.25n

* CHECK dout0_13 Vdout0_13ck126 = 0 time = 6350
.meas tran vdout0_13ck126 FIND v(dout0_13) AT=6350.25n

* CHECK dout0_14 Vdout0_14ck126 = 0 time = 6350
.meas tran vdout0_14ck126 FIND v(dout0_14) AT=6350.25n

* CHECK dout0_15 Vdout0_15ck126 = 0 time = 6350
.meas tran vdout0_15ck126 FIND v(dout0_15) AT=6350.25n

* CHECK dout0_0 Vdout0_0ck128 = 0 time = 6450
.meas tran vdout0_0ck128 FIND v(dout0_0) AT=6450.25n

* CHECK dout0_1 Vdout0_1ck128 = 0 time = 6450
.meas tran vdout0_1ck128 FIND v(dout0_1) AT=6450.25n

* CHECK dout0_2 Vdout0_2ck128 = 0 time = 6450
.meas tran vdout0_2ck128 FIND v(dout0_2) AT=6450.25n

* CHECK dout0_3 Vdout0_3ck128 = 0 time = 6450
.meas tran vdout0_3ck128 FIND v(dout0_3) AT=6450.25n

* CHECK dout0_4 Vdout0_4ck128 = 1.8 time = 6450
.meas tran vdout0_4ck128 FIND v(dout0_4) AT=6450.25n

* CHECK dout0_5 Vdout0_5ck128 = 0 time = 6450
.meas tran vdout0_5ck128 FIND v(dout0_5) AT=6450.25n

* CHECK dout0_6 Vdout0_6ck128 = 0 time = 6450
.meas tran vdout0_6ck128 FIND v(dout0_6) AT=6450.25n

* CHECK dout0_7 Vdout0_7ck128 = 1.8 time = 6450
.meas tran vdout0_7ck128 FIND v(dout0_7) AT=6450.25n

* CHECK dout0_8 Vdout0_8ck128 = 0 time = 6450
.meas tran vdout0_8ck128 FIND v(dout0_8) AT=6450.25n

* CHECK dout0_9 Vdout0_9ck128 = 0 time = 6450
.meas tran vdout0_9ck128 FIND v(dout0_9) AT=6450.25n

* CHECK dout0_10 Vdout0_10ck128 = 0 time = 6450
.meas tran vdout0_10ck128 FIND v(dout0_10) AT=6450.25n

* CHECK dout0_11 Vdout0_11ck128 = 0 time = 6450
.meas tran vdout0_11ck128 FIND v(dout0_11) AT=6450.25n

* CHECK dout0_12 Vdout0_12ck128 = 1.8 time = 6450
.meas tran vdout0_12ck128 FIND v(dout0_12) AT=6450.25n

* CHECK dout0_13 Vdout0_13ck128 = 0 time = 6450
.meas tran vdout0_13ck128 FIND v(dout0_13) AT=6450.25n

* CHECK dout0_14 Vdout0_14ck128 = 0 time = 6450
.meas tran vdout0_14ck128 FIND v(dout0_14) AT=6450.25n

* CHECK dout0_15 Vdout0_15ck128 = 0 time = 6450
.meas tran vdout0_15ck128 FIND v(dout0_15) AT=6450.25n

* CHECK dout0_0 Vdout0_0ck129 = 0 time = 6500
.meas tran vdout0_0ck129 FIND v(dout0_0) AT=6500.25n

* CHECK dout0_1 Vdout0_1ck129 = 0 time = 6500
.meas tran vdout0_1ck129 FIND v(dout0_1) AT=6500.25n

* CHECK dout0_2 Vdout0_2ck129 = 0 time = 6500
.meas tran vdout0_2ck129 FIND v(dout0_2) AT=6500.25n

* CHECK dout0_3 Vdout0_3ck129 = 1.8 time = 6500
.meas tran vdout0_3ck129 FIND v(dout0_3) AT=6500.25n

* CHECK dout0_4 Vdout0_4ck129 = 1.8 time = 6500
.meas tran vdout0_4ck129 FIND v(dout0_4) AT=6500.25n

* CHECK dout0_5 Vdout0_5ck129 = 0 time = 6500
.meas tran vdout0_5ck129 FIND v(dout0_5) AT=6500.25n

* CHECK dout0_6 Vdout0_6ck129 = 0 time = 6500
.meas tran vdout0_6ck129 FIND v(dout0_6) AT=6500.25n

* CHECK dout0_7 Vdout0_7ck129 = 0 time = 6500
.meas tran vdout0_7ck129 FIND v(dout0_7) AT=6500.25n

* CHECK dout0_8 Vdout0_8ck129 = 0 time = 6500
.meas tran vdout0_8ck129 FIND v(dout0_8) AT=6500.25n

* CHECK dout0_9 Vdout0_9ck129 = 1.8 time = 6500
.meas tran vdout0_9ck129 FIND v(dout0_9) AT=6500.25n

* CHECK dout0_10 Vdout0_10ck129 = 0 time = 6500
.meas tran vdout0_10ck129 FIND v(dout0_10) AT=6500.25n

* CHECK dout0_11 Vdout0_11ck129 = 1.8 time = 6500
.meas tran vdout0_11ck129 FIND v(dout0_11) AT=6500.25n

* CHECK dout0_12 Vdout0_12ck129 = 1.8 time = 6500
.meas tran vdout0_12ck129 FIND v(dout0_12) AT=6500.25n

* CHECK dout0_13 Vdout0_13ck129 = 0 time = 6500
.meas tran vdout0_13ck129 FIND v(dout0_13) AT=6500.25n

* CHECK dout0_14 Vdout0_14ck129 = 1.8 time = 6500
.meas tran vdout0_14ck129 FIND v(dout0_14) AT=6500.25n

* CHECK dout0_15 Vdout0_15ck129 = 1.8 time = 6500
.meas tran vdout0_15ck129 FIND v(dout0_15) AT=6500.25n

* CHECK dout0_0 Vdout0_0ck130 = 1.8 time = 6550
.meas tran vdout0_0ck130 FIND v(dout0_0) AT=6550.25n

* CHECK dout0_1 Vdout0_1ck130 = 0 time = 6550
.meas tran vdout0_1ck130 FIND v(dout0_1) AT=6550.25n

* CHECK dout0_2 Vdout0_2ck130 = 0 time = 6550
.meas tran vdout0_2ck130 FIND v(dout0_2) AT=6550.25n

* CHECK dout0_3 Vdout0_3ck130 = 1.8 time = 6550
.meas tran vdout0_3ck130 FIND v(dout0_3) AT=6550.25n

* CHECK dout0_4 Vdout0_4ck130 = 0 time = 6550
.meas tran vdout0_4ck130 FIND v(dout0_4) AT=6550.25n

* CHECK dout0_5 Vdout0_5ck130 = 0 time = 6550
.meas tran vdout0_5ck130 FIND v(dout0_5) AT=6550.25n

* CHECK dout0_6 Vdout0_6ck130 = 1.8 time = 6550
.meas tran vdout0_6ck130 FIND v(dout0_6) AT=6550.25n

* CHECK dout0_7 Vdout0_7ck130 = 1.8 time = 6550
.meas tran vdout0_7ck130 FIND v(dout0_7) AT=6550.25n

* CHECK dout0_8 Vdout0_8ck130 = 1.8 time = 6550
.meas tran vdout0_8ck130 FIND v(dout0_8) AT=6550.25n

* CHECK dout0_9 Vdout0_9ck130 = 0 time = 6550
.meas tran vdout0_9ck130 FIND v(dout0_9) AT=6550.25n

* CHECK dout0_10 Vdout0_10ck130 = 1.8 time = 6550
.meas tran vdout0_10ck130 FIND v(dout0_10) AT=6550.25n

* CHECK dout0_11 Vdout0_11ck130 = 0 time = 6550
.meas tran vdout0_11ck130 FIND v(dout0_11) AT=6550.25n

* CHECK dout0_12 Vdout0_12ck130 = 0 time = 6550
.meas tran vdout0_12ck130 FIND v(dout0_12) AT=6550.25n

* CHECK dout0_13 Vdout0_13ck130 = 1.8 time = 6550
.meas tran vdout0_13ck130 FIND v(dout0_13) AT=6550.25n

* CHECK dout0_14 Vdout0_14ck130 = 1.8 time = 6550
.meas tran vdout0_14ck130 FIND v(dout0_14) AT=6550.25n

* CHECK dout0_15 Vdout0_15ck130 = 0 time = 6550
.meas tran vdout0_15ck130 FIND v(dout0_15) AT=6550.25n

* CHECK dout0_0 Vdout0_0ck131 = 1.8 time = 6600
.meas tran vdout0_0ck131 FIND v(dout0_0) AT=6600.25n

* CHECK dout0_1 Vdout0_1ck131 = 0 time = 6600
.meas tran vdout0_1ck131 FIND v(dout0_1) AT=6600.25n

* CHECK dout0_2 Vdout0_2ck131 = 1.8 time = 6600
.meas tran vdout0_2ck131 FIND v(dout0_2) AT=6600.25n

* CHECK dout0_3 Vdout0_3ck131 = 0 time = 6600
.meas tran vdout0_3ck131 FIND v(dout0_3) AT=6600.25n

* CHECK dout0_4 Vdout0_4ck131 = 0 time = 6600
.meas tran vdout0_4ck131 FIND v(dout0_4) AT=6600.25n

* CHECK dout0_5 Vdout0_5ck131 = 1.8 time = 6600
.meas tran vdout0_5ck131 FIND v(dout0_5) AT=6600.25n

* CHECK dout0_6 Vdout0_6ck131 = 1.8 time = 6600
.meas tran vdout0_6ck131 FIND v(dout0_6) AT=6600.25n

* CHECK dout0_7 Vdout0_7ck131 = 0 time = 6600
.meas tran vdout0_7ck131 FIND v(dout0_7) AT=6600.25n

* CHECK dout0_8 Vdout0_8ck131 = 0 time = 6600
.meas tran vdout0_8ck131 FIND v(dout0_8) AT=6600.25n

* CHECK dout0_9 Vdout0_9ck131 = 1.8 time = 6600
.meas tran vdout0_9ck131 FIND v(dout0_9) AT=6600.25n

* CHECK dout0_10 Vdout0_10ck131 = 0 time = 6600
.meas tran vdout0_10ck131 FIND v(dout0_10) AT=6600.25n

* CHECK dout0_11 Vdout0_11ck131 = 1.8 time = 6600
.meas tran vdout0_11ck131 FIND v(dout0_11) AT=6600.25n

* CHECK dout0_12 Vdout0_12ck131 = 1.8 time = 6600
.meas tran vdout0_12ck131 FIND v(dout0_12) AT=6600.25n

* CHECK dout0_13 Vdout0_13ck131 = 0 time = 6600
.meas tran vdout0_13ck131 FIND v(dout0_13) AT=6600.25n

* CHECK dout0_14 Vdout0_14ck131 = 0 time = 6600
.meas tran vdout0_14ck131 FIND v(dout0_14) AT=6600.25n

* CHECK dout0_15 Vdout0_15ck131 = 1.8 time = 6600
.meas tran vdout0_15ck131 FIND v(dout0_15) AT=6600.25n

* CHECK dout0_0 Vdout0_0ck133 = 0 time = 6700
.meas tran vdout0_0ck133 FIND v(dout0_0) AT=6700.25n

* CHECK dout0_1 Vdout0_1ck133 = 0 time = 6700
.meas tran vdout0_1ck133 FIND v(dout0_1) AT=6700.25n

* CHECK dout0_2 Vdout0_2ck133 = 1.8 time = 6700
.meas tran vdout0_2ck133 FIND v(dout0_2) AT=6700.25n

* CHECK dout0_3 Vdout0_3ck133 = 0 time = 6700
.meas tran vdout0_3ck133 FIND v(dout0_3) AT=6700.25n

* CHECK dout0_4 Vdout0_4ck133 = 0 time = 6700
.meas tran vdout0_4ck133 FIND v(dout0_4) AT=6700.25n

* CHECK dout0_5 Vdout0_5ck133 = 1.8 time = 6700
.meas tran vdout0_5ck133 FIND v(dout0_5) AT=6700.25n

* CHECK dout0_6 Vdout0_6ck133 = 0 time = 6700
.meas tran vdout0_6ck133 FIND v(dout0_6) AT=6700.25n

* CHECK dout0_7 Vdout0_7ck133 = 1.8 time = 6700
.meas tran vdout0_7ck133 FIND v(dout0_7) AT=6700.25n

* CHECK dout0_8 Vdout0_8ck133 = 1.8 time = 6700
.meas tran vdout0_8ck133 FIND v(dout0_8) AT=6700.25n

* CHECK dout0_9 Vdout0_9ck133 = 1.8 time = 6700
.meas tran vdout0_9ck133 FIND v(dout0_9) AT=6700.25n

* CHECK dout0_10 Vdout0_10ck133 = 1.8 time = 6700
.meas tran vdout0_10ck133 FIND v(dout0_10) AT=6700.25n

* CHECK dout0_11 Vdout0_11ck133 = 1.8 time = 6700
.meas tran vdout0_11ck133 FIND v(dout0_11) AT=6700.25n

* CHECK dout0_12 Vdout0_12ck133 = 0 time = 6700
.meas tran vdout0_12ck133 FIND v(dout0_12) AT=6700.25n

* CHECK dout0_13 Vdout0_13ck133 = 0 time = 6700
.meas tran vdout0_13ck133 FIND v(dout0_13) AT=6700.25n

* CHECK dout0_14 Vdout0_14ck133 = 0 time = 6700
.meas tran vdout0_14ck133 FIND v(dout0_14) AT=6700.25n

* CHECK dout0_15 Vdout0_15ck133 = 1.8 time = 6700
.meas tran vdout0_15ck133 FIND v(dout0_15) AT=6700.25n

* CHECK dout0_0 Vdout0_0ck134 = 0 time = 6750
.meas tran vdout0_0ck134 FIND v(dout0_0) AT=6750.25n

* CHECK dout0_1 Vdout0_1ck134 = 1.8 time = 6750
.meas tran vdout0_1ck134 FIND v(dout0_1) AT=6750.25n

* CHECK dout0_2 Vdout0_2ck134 = 0 time = 6750
.meas tran vdout0_2ck134 FIND v(dout0_2) AT=6750.25n

* CHECK dout0_3 Vdout0_3ck134 = 0 time = 6750
.meas tran vdout0_3ck134 FIND v(dout0_3) AT=6750.25n

* CHECK dout0_4 Vdout0_4ck134 = 1.8 time = 6750
.meas tran vdout0_4ck134 FIND v(dout0_4) AT=6750.25n

* CHECK dout0_5 Vdout0_5ck134 = 0 time = 6750
.meas tran vdout0_5ck134 FIND v(dout0_5) AT=6750.25n

* CHECK dout0_6 Vdout0_6ck134 = 1.8 time = 6750
.meas tran vdout0_6ck134 FIND v(dout0_6) AT=6750.25n

* CHECK dout0_7 Vdout0_7ck134 = 0 time = 6750
.meas tran vdout0_7ck134 FIND v(dout0_7) AT=6750.25n

* CHECK dout0_8 Vdout0_8ck134 = 1.8 time = 6750
.meas tran vdout0_8ck134 FIND v(dout0_8) AT=6750.25n

* CHECK dout0_9 Vdout0_9ck134 = 1.8 time = 6750
.meas tran vdout0_9ck134 FIND v(dout0_9) AT=6750.25n

* CHECK dout0_10 Vdout0_10ck134 = 0 time = 6750
.meas tran vdout0_10ck134 FIND v(dout0_10) AT=6750.25n

* CHECK dout0_11 Vdout0_11ck134 = 1.8 time = 6750
.meas tran vdout0_11ck134 FIND v(dout0_11) AT=6750.25n

* CHECK dout0_12 Vdout0_12ck134 = 0 time = 6750
.meas tran vdout0_12ck134 FIND v(dout0_12) AT=6750.25n

* CHECK dout0_13 Vdout0_13ck134 = 1.8 time = 6750
.meas tran vdout0_13ck134 FIND v(dout0_13) AT=6750.25n

* CHECK dout0_14 Vdout0_14ck134 = 0 time = 6750
.meas tran vdout0_14ck134 FIND v(dout0_14) AT=6750.25n

* CHECK dout0_15 Vdout0_15ck134 = 1.8 time = 6750
.meas tran vdout0_15ck134 FIND v(dout0_15) AT=6750.25n

* CHECK dout0_0 Vdout0_0ck135 = 1.8 time = 6800
.meas tran vdout0_0ck135 FIND v(dout0_0) AT=6800.25n

* CHECK dout0_1 Vdout0_1ck135 = 0 time = 6800
.meas tran vdout0_1ck135 FIND v(dout0_1) AT=6800.25n

* CHECK dout0_2 Vdout0_2ck135 = 0 time = 6800
.meas tran vdout0_2ck135 FIND v(dout0_2) AT=6800.25n

* CHECK dout0_3 Vdout0_3ck135 = 1.8 time = 6800
.meas tran vdout0_3ck135 FIND v(dout0_3) AT=6800.25n

* CHECK dout0_4 Vdout0_4ck135 = 0 time = 6800
.meas tran vdout0_4ck135 FIND v(dout0_4) AT=6800.25n

* CHECK dout0_5 Vdout0_5ck135 = 0 time = 6800
.meas tran vdout0_5ck135 FIND v(dout0_5) AT=6800.25n

* CHECK dout0_6 Vdout0_6ck135 = 1.8 time = 6800
.meas tran vdout0_6ck135 FIND v(dout0_6) AT=6800.25n

* CHECK dout0_7 Vdout0_7ck135 = 1.8 time = 6800
.meas tran vdout0_7ck135 FIND v(dout0_7) AT=6800.25n

* CHECK dout0_8 Vdout0_8ck135 = 1.8 time = 6800
.meas tran vdout0_8ck135 FIND v(dout0_8) AT=6800.25n

* CHECK dout0_9 Vdout0_9ck135 = 0 time = 6800
.meas tran vdout0_9ck135 FIND v(dout0_9) AT=6800.25n

* CHECK dout0_10 Vdout0_10ck135 = 1.8 time = 6800
.meas tran vdout0_10ck135 FIND v(dout0_10) AT=6800.25n

* CHECK dout0_11 Vdout0_11ck135 = 0 time = 6800
.meas tran vdout0_11ck135 FIND v(dout0_11) AT=6800.25n

* CHECK dout0_12 Vdout0_12ck135 = 0 time = 6800
.meas tran vdout0_12ck135 FIND v(dout0_12) AT=6800.25n

* CHECK dout0_13 Vdout0_13ck135 = 1.8 time = 6800
.meas tran vdout0_13ck135 FIND v(dout0_13) AT=6800.25n

* CHECK dout0_14 Vdout0_14ck135 = 1.8 time = 6800
.meas tran vdout0_14ck135 FIND v(dout0_14) AT=6800.25n

* CHECK dout0_15 Vdout0_15ck135 = 0 time = 6800
.meas tran vdout0_15ck135 FIND v(dout0_15) AT=6800.25n

* CHECK dout0_0 Vdout0_0ck138 = 1.8 time = 6950
.meas tran vdout0_0ck138 FIND v(dout0_0) AT=6950.25n

* CHECK dout0_1 Vdout0_1ck138 = 0 time = 6950
.meas tran vdout0_1ck138 FIND v(dout0_1) AT=6950.25n

* CHECK dout0_2 Vdout0_2ck138 = 1.8 time = 6950
.meas tran vdout0_2ck138 FIND v(dout0_2) AT=6950.25n

* CHECK dout0_3 Vdout0_3ck138 = 0 time = 6950
.meas tran vdout0_3ck138 FIND v(dout0_3) AT=6950.25n

* CHECK dout0_4 Vdout0_4ck138 = 1.8 time = 6950
.meas tran vdout0_4ck138 FIND v(dout0_4) AT=6950.25n

* CHECK dout0_5 Vdout0_5ck138 = 0 time = 6950
.meas tran vdout0_5ck138 FIND v(dout0_5) AT=6950.25n

* CHECK dout0_6 Vdout0_6ck138 = 0 time = 6950
.meas tran vdout0_6ck138 FIND v(dout0_6) AT=6950.25n

* CHECK dout0_7 Vdout0_7ck138 = 1.8 time = 6950
.meas tran vdout0_7ck138 FIND v(dout0_7) AT=6950.25n

* CHECK dout0_8 Vdout0_8ck138 = 0 time = 6950
.meas tran vdout0_8ck138 FIND v(dout0_8) AT=6950.25n

* CHECK dout0_9 Vdout0_9ck138 = 1.8 time = 6950
.meas tran vdout0_9ck138 FIND v(dout0_9) AT=6950.25n

* CHECK dout0_10 Vdout0_10ck138 = 1.8 time = 6950
.meas tran vdout0_10ck138 FIND v(dout0_10) AT=6950.25n

* CHECK dout0_11 Vdout0_11ck138 = 1.8 time = 6950
.meas tran vdout0_11ck138 FIND v(dout0_11) AT=6950.25n

* CHECK dout0_12 Vdout0_12ck138 = 0 time = 6950
.meas tran vdout0_12ck138 FIND v(dout0_12) AT=6950.25n

* CHECK dout0_13 Vdout0_13ck138 = 0 time = 6950
.meas tran vdout0_13ck138 FIND v(dout0_13) AT=6950.25n

* CHECK dout0_14 Vdout0_14ck138 = 1.8 time = 6950
.meas tran vdout0_14ck138 FIND v(dout0_14) AT=6950.25n

* CHECK dout0_15 Vdout0_15ck138 = 0 time = 6950
.meas tran vdout0_15ck138 FIND v(dout0_15) AT=6950.25n

* CHECK dout0_0 Vdout0_0ck140 = 0 time = 7050
.meas tran vdout0_0ck140 FIND v(dout0_0) AT=7050.25n

* CHECK dout0_1 Vdout0_1ck140 = 0 time = 7050
.meas tran vdout0_1ck140 FIND v(dout0_1) AT=7050.25n

* CHECK dout0_2 Vdout0_2ck140 = 1.8 time = 7050
.meas tran vdout0_2ck140 FIND v(dout0_2) AT=7050.25n

* CHECK dout0_3 Vdout0_3ck140 = 1.8 time = 7050
.meas tran vdout0_3ck140 FIND v(dout0_3) AT=7050.25n

* CHECK dout0_4 Vdout0_4ck140 = 0 time = 7050
.meas tran vdout0_4ck140 FIND v(dout0_4) AT=7050.25n

* CHECK dout0_5 Vdout0_5ck140 = 1.8 time = 7050
.meas tran vdout0_5ck140 FIND v(dout0_5) AT=7050.25n

* CHECK dout0_6 Vdout0_6ck140 = 1.8 time = 7050
.meas tran vdout0_6ck140 FIND v(dout0_6) AT=7050.25n

* CHECK dout0_7 Vdout0_7ck140 = 0 time = 7050
.meas tran vdout0_7ck140 FIND v(dout0_7) AT=7050.25n

* CHECK dout0_8 Vdout0_8ck140 = 1.8 time = 7050
.meas tran vdout0_8ck140 FIND v(dout0_8) AT=7050.25n

* CHECK dout0_9 Vdout0_9ck140 = 0 time = 7050
.meas tran vdout0_9ck140 FIND v(dout0_9) AT=7050.25n

* CHECK dout0_10 Vdout0_10ck140 = 0 time = 7050
.meas tran vdout0_10ck140 FIND v(dout0_10) AT=7050.25n

* CHECK dout0_11 Vdout0_11ck140 = 1.8 time = 7050
.meas tran vdout0_11ck140 FIND v(dout0_11) AT=7050.25n

* CHECK dout0_12 Vdout0_12ck140 = 1.8 time = 7050
.meas tran vdout0_12ck140 FIND v(dout0_12) AT=7050.25n

* CHECK dout0_13 Vdout0_13ck140 = 1.8 time = 7050
.meas tran vdout0_13ck140 FIND v(dout0_13) AT=7050.25n

* CHECK dout0_14 Vdout0_14ck140 = 0 time = 7050
.meas tran vdout0_14ck140 FIND v(dout0_14) AT=7050.25n

* CHECK dout0_15 Vdout0_15ck140 = 1.8 time = 7050
.meas tran vdout0_15ck140 FIND v(dout0_15) AT=7050.25n

* CHECK dout0_0 Vdout0_0ck143 = 1.8 time = 7200
.meas tran vdout0_0ck143 FIND v(dout0_0) AT=7200.25n

* CHECK dout0_1 Vdout0_1ck143 = 1.8 time = 7200
.meas tran vdout0_1ck143 FIND v(dout0_1) AT=7200.25n

* CHECK dout0_2 Vdout0_2ck143 = 1.8 time = 7200
.meas tran vdout0_2ck143 FIND v(dout0_2) AT=7200.25n

* CHECK dout0_3 Vdout0_3ck143 = 1.8 time = 7200
.meas tran vdout0_3ck143 FIND v(dout0_3) AT=7200.25n

* CHECK dout0_4 Vdout0_4ck143 = 0 time = 7200
.meas tran vdout0_4ck143 FIND v(dout0_4) AT=7200.25n

* CHECK dout0_5 Vdout0_5ck143 = 0 time = 7200
.meas tran vdout0_5ck143 FIND v(dout0_5) AT=7200.25n

* CHECK dout0_6 Vdout0_6ck143 = 1.8 time = 7200
.meas tran vdout0_6ck143 FIND v(dout0_6) AT=7200.25n

* CHECK dout0_7 Vdout0_7ck143 = 1.8 time = 7200
.meas tran vdout0_7ck143 FIND v(dout0_7) AT=7200.25n

* CHECK dout0_8 Vdout0_8ck143 = 0 time = 7200
.meas tran vdout0_8ck143 FIND v(dout0_8) AT=7200.25n

* CHECK dout0_9 Vdout0_9ck143 = 0 time = 7200
.meas tran vdout0_9ck143 FIND v(dout0_9) AT=7200.25n

* CHECK dout0_10 Vdout0_10ck143 = 1.8 time = 7200
.meas tran vdout0_10ck143 FIND v(dout0_10) AT=7200.25n

* CHECK dout0_11 Vdout0_11ck143 = 1.8 time = 7200
.meas tran vdout0_11ck143 FIND v(dout0_11) AT=7200.25n

* CHECK dout0_12 Vdout0_12ck143 = 0 time = 7200
.meas tran vdout0_12ck143 FIND v(dout0_12) AT=7200.25n

* CHECK dout0_13 Vdout0_13ck143 = 0 time = 7200
.meas tran vdout0_13ck143 FIND v(dout0_13) AT=7200.25n

* CHECK dout0_14 Vdout0_14ck143 = 0 time = 7200
.meas tran vdout0_14ck143 FIND v(dout0_14) AT=7200.25n

* CHECK dout0_15 Vdout0_15ck143 = 1.8 time = 7200
.meas tran vdout0_15ck143 FIND v(dout0_15) AT=7200.25n

* CHECK dout0_0 Vdout0_0ck145 = 1.8 time = 7300
.meas tran vdout0_0ck145 FIND v(dout0_0) AT=7300.25n

* CHECK dout0_1 Vdout0_1ck145 = 0 time = 7300
.meas tran vdout0_1ck145 FIND v(dout0_1) AT=7300.25n

* CHECK dout0_2 Vdout0_2ck145 = 1.8 time = 7300
.meas tran vdout0_2ck145 FIND v(dout0_2) AT=7300.25n

* CHECK dout0_3 Vdout0_3ck145 = 0 time = 7300
.meas tran vdout0_3ck145 FIND v(dout0_3) AT=7300.25n

* CHECK dout0_4 Vdout0_4ck145 = 1.8 time = 7300
.meas tran vdout0_4ck145 FIND v(dout0_4) AT=7300.25n

* CHECK dout0_5 Vdout0_5ck145 = 1.8 time = 7300
.meas tran vdout0_5ck145 FIND v(dout0_5) AT=7300.25n

* CHECK dout0_6 Vdout0_6ck145 = 1.8 time = 7300
.meas tran vdout0_6ck145 FIND v(dout0_6) AT=7300.25n

* CHECK dout0_7 Vdout0_7ck145 = 0 time = 7300
.meas tran vdout0_7ck145 FIND v(dout0_7) AT=7300.25n

* CHECK dout0_8 Vdout0_8ck145 = 1.8 time = 7300
.meas tran vdout0_8ck145 FIND v(dout0_8) AT=7300.25n

* CHECK dout0_9 Vdout0_9ck145 = 1.8 time = 7300
.meas tran vdout0_9ck145 FIND v(dout0_9) AT=7300.25n

* CHECK dout0_10 Vdout0_10ck145 = 1.8 time = 7300
.meas tran vdout0_10ck145 FIND v(dout0_10) AT=7300.25n

* CHECK dout0_11 Vdout0_11ck145 = 0 time = 7300
.meas tran vdout0_11ck145 FIND v(dout0_11) AT=7300.25n

* CHECK dout0_12 Vdout0_12ck145 = 1.8 time = 7300
.meas tran vdout0_12ck145 FIND v(dout0_12) AT=7300.25n

* CHECK dout0_13 Vdout0_13ck145 = 1.8 time = 7300
.meas tran vdout0_13ck145 FIND v(dout0_13) AT=7300.25n

* CHECK dout0_14 Vdout0_14ck145 = 1.8 time = 7300
.meas tran vdout0_14ck145 FIND v(dout0_14) AT=7300.25n

* CHECK dout0_15 Vdout0_15ck145 = 0 time = 7300
.meas tran vdout0_15ck145 FIND v(dout0_15) AT=7300.25n

* CHECK dout0_0 Vdout0_0ck147 = 0 time = 7400
.meas tran vdout0_0ck147 FIND v(dout0_0) AT=7400.25n

* CHECK dout0_1 Vdout0_1ck147 = 0 time = 7400
.meas tran vdout0_1ck147 FIND v(dout0_1) AT=7400.25n

* CHECK dout0_2 Vdout0_2ck147 = 1.8 time = 7400
.meas tran vdout0_2ck147 FIND v(dout0_2) AT=7400.25n

* CHECK dout0_3 Vdout0_3ck147 = 0 time = 7400
.meas tran vdout0_3ck147 FIND v(dout0_3) AT=7400.25n

* CHECK dout0_4 Vdout0_4ck147 = 0 time = 7400
.meas tran vdout0_4ck147 FIND v(dout0_4) AT=7400.25n

* CHECK dout0_5 Vdout0_5ck147 = 1.8 time = 7400
.meas tran vdout0_5ck147 FIND v(dout0_5) AT=7400.25n

* CHECK dout0_6 Vdout0_6ck147 = 0 time = 7400
.meas tran vdout0_6ck147 FIND v(dout0_6) AT=7400.25n

* CHECK dout0_7 Vdout0_7ck147 = 1.8 time = 7400
.meas tran vdout0_7ck147 FIND v(dout0_7) AT=7400.25n

* CHECK dout0_8 Vdout0_8ck147 = 1.8 time = 7400
.meas tran vdout0_8ck147 FIND v(dout0_8) AT=7400.25n

* CHECK dout0_9 Vdout0_9ck147 = 1.8 time = 7400
.meas tran vdout0_9ck147 FIND v(dout0_9) AT=7400.25n

* CHECK dout0_10 Vdout0_10ck147 = 1.8 time = 7400
.meas tran vdout0_10ck147 FIND v(dout0_10) AT=7400.25n

* CHECK dout0_11 Vdout0_11ck147 = 1.8 time = 7400
.meas tran vdout0_11ck147 FIND v(dout0_11) AT=7400.25n

* CHECK dout0_12 Vdout0_12ck147 = 0 time = 7400
.meas tran vdout0_12ck147 FIND v(dout0_12) AT=7400.25n

* CHECK dout0_13 Vdout0_13ck147 = 0 time = 7400
.meas tran vdout0_13ck147 FIND v(dout0_13) AT=7400.25n

* CHECK dout0_14 Vdout0_14ck147 = 0 time = 7400
.meas tran vdout0_14ck147 FIND v(dout0_14) AT=7400.25n

* CHECK dout0_15 Vdout0_15ck147 = 1.8 time = 7400
.meas tran vdout0_15ck147 FIND v(dout0_15) AT=7400.25n

* CHECK dout0_0 Vdout0_0ck148 = 1.8 time = 7450
.meas tran vdout0_0ck148 FIND v(dout0_0) AT=7450.25n

* CHECK dout0_1 Vdout0_1ck148 = 0 time = 7450
.meas tran vdout0_1ck148 FIND v(dout0_1) AT=7450.25n

* CHECK dout0_2 Vdout0_2ck148 = 1.8 time = 7450
.meas tran vdout0_2ck148 FIND v(dout0_2) AT=7450.25n

* CHECK dout0_3 Vdout0_3ck148 = 0 time = 7450
.meas tran vdout0_3ck148 FIND v(dout0_3) AT=7450.25n

* CHECK dout0_4 Vdout0_4ck148 = 1.8 time = 7450
.meas tran vdout0_4ck148 FIND v(dout0_4) AT=7450.25n

* CHECK dout0_5 Vdout0_5ck148 = 1.8 time = 7450
.meas tran vdout0_5ck148 FIND v(dout0_5) AT=7450.25n

* CHECK dout0_6 Vdout0_6ck148 = 0 time = 7450
.meas tran vdout0_6ck148 FIND v(dout0_6) AT=7450.25n

* CHECK dout0_7 Vdout0_7ck148 = 0 time = 7450
.meas tran vdout0_7ck148 FIND v(dout0_7) AT=7450.25n

* CHECK dout0_8 Vdout0_8ck148 = 0 time = 7450
.meas tran vdout0_8ck148 FIND v(dout0_8) AT=7450.25n

* CHECK dout0_9 Vdout0_9ck148 = 0 time = 7450
.meas tran vdout0_9ck148 FIND v(dout0_9) AT=7450.25n

* CHECK dout0_10 Vdout0_10ck148 = 0 time = 7450
.meas tran vdout0_10ck148 FIND v(dout0_10) AT=7450.25n

* CHECK dout0_11 Vdout0_11ck148 = 0 time = 7450
.meas tran vdout0_11ck148 FIND v(dout0_11) AT=7450.25n

* CHECK dout0_12 Vdout0_12ck148 = 0 time = 7450
.meas tran vdout0_12ck148 FIND v(dout0_12) AT=7450.25n

* CHECK dout0_13 Vdout0_13ck148 = 0 time = 7450
.meas tran vdout0_13ck148 FIND v(dout0_13) AT=7450.25n

* CHECK dout0_14 Vdout0_14ck148 = 0 time = 7450
.meas tran vdout0_14ck148 FIND v(dout0_14) AT=7450.25n

* CHECK dout0_15 Vdout0_15ck148 = 1.8 time = 7450
.meas tran vdout0_15ck148 FIND v(dout0_15) AT=7450.25n

* CHECK dout0_0 Vdout0_0ck151 = 0 time = 7600
.meas tran vdout0_0ck151 FIND v(dout0_0) AT=7600.25n

* CHECK dout0_1 Vdout0_1ck151 = 0 time = 7600
.meas tran vdout0_1ck151 FIND v(dout0_1) AT=7600.25n

* CHECK dout0_2 Vdout0_2ck151 = 1.8 time = 7600
.meas tran vdout0_2ck151 FIND v(dout0_2) AT=7600.25n

* CHECK dout0_3 Vdout0_3ck151 = 0 time = 7600
.meas tran vdout0_3ck151 FIND v(dout0_3) AT=7600.25n

* CHECK dout0_4 Vdout0_4ck151 = 0 time = 7600
.meas tran vdout0_4ck151 FIND v(dout0_4) AT=7600.25n

* CHECK dout0_5 Vdout0_5ck151 = 1.8 time = 7600
.meas tran vdout0_5ck151 FIND v(dout0_5) AT=7600.25n

* CHECK dout0_6 Vdout0_6ck151 = 0 time = 7600
.meas tran vdout0_6ck151 FIND v(dout0_6) AT=7600.25n

* CHECK dout0_7 Vdout0_7ck151 = 1.8 time = 7600
.meas tran vdout0_7ck151 FIND v(dout0_7) AT=7600.25n

* CHECK dout0_8 Vdout0_8ck151 = 1.8 time = 7600
.meas tran vdout0_8ck151 FIND v(dout0_8) AT=7600.25n

* CHECK dout0_9 Vdout0_9ck151 = 1.8 time = 7600
.meas tran vdout0_9ck151 FIND v(dout0_9) AT=7600.25n

* CHECK dout0_10 Vdout0_10ck151 = 1.8 time = 7600
.meas tran vdout0_10ck151 FIND v(dout0_10) AT=7600.25n

* CHECK dout0_11 Vdout0_11ck151 = 1.8 time = 7600
.meas tran vdout0_11ck151 FIND v(dout0_11) AT=7600.25n

* CHECK dout0_12 Vdout0_12ck151 = 0 time = 7600
.meas tran vdout0_12ck151 FIND v(dout0_12) AT=7600.25n

* CHECK dout0_13 Vdout0_13ck151 = 0 time = 7600
.meas tran vdout0_13ck151 FIND v(dout0_13) AT=7600.25n

* CHECK dout0_14 Vdout0_14ck151 = 0 time = 7600
.meas tran vdout0_14ck151 FIND v(dout0_14) AT=7600.25n

* CHECK dout0_15 Vdout0_15ck151 = 1.8 time = 7600
.meas tran vdout0_15ck151 FIND v(dout0_15) AT=7600.25n

* CHECK dout0_0 Vdout0_0ck152 = 1.8 time = 7650
.meas tran vdout0_0ck152 FIND v(dout0_0) AT=7650.25n

* CHECK dout0_1 Vdout0_1ck152 = 0 time = 7650
.meas tran vdout0_1ck152 FIND v(dout0_1) AT=7650.25n

* CHECK dout0_2 Vdout0_2ck152 = 0 time = 7650
.meas tran vdout0_2ck152 FIND v(dout0_2) AT=7650.25n

* CHECK dout0_3 Vdout0_3ck152 = 1.8 time = 7650
.meas tran vdout0_3ck152 FIND v(dout0_3) AT=7650.25n

* CHECK dout0_4 Vdout0_4ck152 = 1.8 time = 7650
.meas tran vdout0_4ck152 FIND v(dout0_4) AT=7650.25n

* CHECK dout0_5 Vdout0_5ck152 = 1.8 time = 7650
.meas tran vdout0_5ck152 FIND v(dout0_5) AT=7650.25n

* CHECK dout0_6 Vdout0_6ck152 = 1.8 time = 7650
.meas tran vdout0_6ck152 FIND v(dout0_6) AT=7650.25n

* CHECK dout0_7 Vdout0_7ck152 = 0 time = 7650
.meas tran vdout0_7ck152 FIND v(dout0_7) AT=7650.25n

* CHECK dout0_8 Vdout0_8ck152 = 0 time = 7650
.meas tran vdout0_8ck152 FIND v(dout0_8) AT=7650.25n

* CHECK dout0_9 Vdout0_9ck152 = 1.8 time = 7650
.meas tran vdout0_9ck152 FIND v(dout0_9) AT=7650.25n

* CHECK dout0_10 Vdout0_10ck152 = 1.8 time = 7650
.meas tran vdout0_10ck152 FIND v(dout0_10) AT=7650.25n

* CHECK dout0_11 Vdout0_11ck152 = 0 time = 7650
.meas tran vdout0_11ck152 FIND v(dout0_11) AT=7650.25n

* CHECK dout0_12 Vdout0_12ck152 = 1.8 time = 7650
.meas tran vdout0_12ck152 FIND v(dout0_12) AT=7650.25n

* CHECK dout0_13 Vdout0_13ck152 = 0 time = 7650
.meas tran vdout0_13ck152 FIND v(dout0_13) AT=7650.25n

* CHECK dout0_14 Vdout0_14ck152 = 0 time = 7650
.meas tran vdout0_14ck152 FIND v(dout0_14) AT=7650.25n

* CHECK dout0_15 Vdout0_15ck152 = 0 time = 7650
.meas tran vdout0_15ck152 FIND v(dout0_15) AT=7650.25n

* CHECK dout0_0 Vdout0_0ck153 = 1.8 time = 7700
.meas tran vdout0_0ck153 FIND v(dout0_0) AT=7700.25n

* CHECK dout0_1 Vdout0_1ck153 = 0 time = 7700
.meas tran vdout0_1ck153 FIND v(dout0_1) AT=7700.25n

* CHECK dout0_2 Vdout0_2ck153 = 1.8 time = 7700
.meas tran vdout0_2ck153 FIND v(dout0_2) AT=7700.25n

* CHECK dout0_3 Vdout0_3ck153 = 0 time = 7700
.meas tran vdout0_3ck153 FIND v(dout0_3) AT=7700.25n

* CHECK dout0_4 Vdout0_4ck153 = 0 time = 7700
.meas tran vdout0_4ck153 FIND v(dout0_4) AT=7700.25n

* CHECK dout0_5 Vdout0_5ck153 = 1.8 time = 7700
.meas tran vdout0_5ck153 FIND v(dout0_5) AT=7700.25n

* CHECK dout0_6 Vdout0_6ck153 = 0 time = 7700
.meas tran vdout0_6ck153 FIND v(dout0_6) AT=7700.25n

* CHECK dout0_7 Vdout0_7ck153 = 1.8 time = 7700
.meas tran vdout0_7ck153 FIND v(dout0_7) AT=7700.25n

* CHECK dout0_8 Vdout0_8ck153 = 1.8 time = 7700
.meas tran vdout0_8ck153 FIND v(dout0_8) AT=7700.25n

* CHECK dout0_9 Vdout0_9ck153 = 1.8 time = 7700
.meas tran vdout0_9ck153 FIND v(dout0_9) AT=7700.25n

* CHECK dout0_10 Vdout0_10ck153 = 1.8 time = 7700
.meas tran vdout0_10ck153 FIND v(dout0_10) AT=7700.25n

* CHECK dout0_11 Vdout0_11ck153 = 0 time = 7700
.meas tran vdout0_11ck153 FIND v(dout0_11) AT=7700.25n

* CHECK dout0_12 Vdout0_12ck153 = 0 time = 7700
.meas tran vdout0_12ck153 FIND v(dout0_12) AT=7700.25n

* CHECK dout0_13 Vdout0_13ck153 = 0 time = 7700
.meas tran vdout0_13ck153 FIND v(dout0_13) AT=7700.25n

* CHECK dout0_14 Vdout0_14ck153 = 0 time = 7700
.meas tran vdout0_14ck153 FIND v(dout0_14) AT=7700.25n

* CHECK dout0_15 Vdout0_15ck153 = 1.8 time = 7700
.meas tran vdout0_15ck153 FIND v(dout0_15) AT=7700.25n

* CHECK dout0_0 Vdout0_0ck155 = 1.8 time = 7800
.meas tran vdout0_0ck155 FIND v(dout0_0) AT=7800.25n

* CHECK dout0_1 Vdout0_1ck155 = 0 time = 7800
.meas tran vdout0_1ck155 FIND v(dout0_1) AT=7800.25n

* CHECK dout0_2 Vdout0_2ck155 = 1.8 time = 7800
.meas tran vdout0_2ck155 FIND v(dout0_2) AT=7800.25n

* CHECK dout0_3 Vdout0_3ck155 = 0 time = 7800
.meas tran vdout0_3ck155 FIND v(dout0_3) AT=7800.25n

* CHECK dout0_4 Vdout0_4ck155 = 1.8 time = 7800
.meas tran vdout0_4ck155 FIND v(dout0_4) AT=7800.25n

* CHECK dout0_5 Vdout0_5ck155 = 1.8 time = 7800
.meas tran vdout0_5ck155 FIND v(dout0_5) AT=7800.25n

* CHECK dout0_6 Vdout0_6ck155 = 1.8 time = 7800
.meas tran vdout0_6ck155 FIND v(dout0_6) AT=7800.25n

* CHECK dout0_7 Vdout0_7ck155 = 0 time = 7800
.meas tran vdout0_7ck155 FIND v(dout0_7) AT=7800.25n

* CHECK dout0_8 Vdout0_8ck155 = 1.8 time = 7800
.meas tran vdout0_8ck155 FIND v(dout0_8) AT=7800.25n

* CHECK dout0_9 Vdout0_9ck155 = 1.8 time = 7800
.meas tran vdout0_9ck155 FIND v(dout0_9) AT=7800.25n

* CHECK dout0_10 Vdout0_10ck155 = 1.8 time = 7800
.meas tran vdout0_10ck155 FIND v(dout0_10) AT=7800.25n

* CHECK dout0_11 Vdout0_11ck155 = 0 time = 7800
.meas tran vdout0_11ck155 FIND v(dout0_11) AT=7800.25n

* CHECK dout0_12 Vdout0_12ck155 = 1.8 time = 7800
.meas tran vdout0_12ck155 FIND v(dout0_12) AT=7800.25n

* CHECK dout0_13 Vdout0_13ck155 = 1.8 time = 7800
.meas tran vdout0_13ck155 FIND v(dout0_13) AT=7800.25n

* CHECK dout0_14 Vdout0_14ck155 = 1.8 time = 7800
.meas tran vdout0_14ck155 FIND v(dout0_14) AT=7800.25n

* CHECK dout0_15 Vdout0_15ck155 = 0 time = 7800
.meas tran vdout0_15ck155 FIND v(dout0_15) AT=7800.25n

* CHECK dout0_0 Vdout0_0ck158 = 0 time = 7950
.meas tran vdout0_0ck158 FIND v(dout0_0) AT=7950.25n

* CHECK dout0_1 Vdout0_1ck158 = 0 time = 7950
.meas tran vdout0_1ck158 FIND v(dout0_1) AT=7950.25n

* CHECK dout0_2 Vdout0_2ck158 = 0 time = 7950
.meas tran vdout0_2ck158 FIND v(dout0_2) AT=7950.25n

* CHECK dout0_3 Vdout0_3ck158 = 0 time = 7950
.meas tran vdout0_3ck158 FIND v(dout0_3) AT=7950.25n

* CHECK dout0_4 Vdout0_4ck158 = 1.8 time = 7950
.meas tran vdout0_4ck158 FIND v(dout0_4) AT=7950.25n

* CHECK dout0_5 Vdout0_5ck158 = 0 time = 7950
.meas tran vdout0_5ck158 FIND v(dout0_5) AT=7950.25n

* CHECK dout0_6 Vdout0_6ck158 = 0 time = 7950
.meas tran vdout0_6ck158 FIND v(dout0_6) AT=7950.25n

* CHECK dout0_7 Vdout0_7ck158 = 1.8 time = 7950
.meas tran vdout0_7ck158 FIND v(dout0_7) AT=7950.25n

* CHECK dout0_8 Vdout0_8ck158 = 0 time = 7950
.meas tran vdout0_8ck158 FIND v(dout0_8) AT=7950.25n

* CHECK dout0_9 Vdout0_9ck158 = 0 time = 7950
.meas tran vdout0_9ck158 FIND v(dout0_9) AT=7950.25n

* CHECK dout0_10 Vdout0_10ck158 = 0 time = 7950
.meas tran vdout0_10ck158 FIND v(dout0_10) AT=7950.25n

* CHECK dout0_11 Vdout0_11ck158 = 0 time = 7950
.meas tran vdout0_11ck158 FIND v(dout0_11) AT=7950.25n

* CHECK dout0_12 Vdout0_12ck158 = 1.8 time = 7950
.meas tran vdout0_12ck158 FIND v(dout0_12) AT=7950.25n

* CHECK dout0_13 Vdout0_13ck158 = 0 time = 7950
.meas tran vdout0_13ck158 FIND v(dout0_13) AT=7950.25n

* CHECK dout0_14 Vdout0_14ck158 = 0 time = 7950
.meas tran vdout0_14ck158 FIND v(dout0_14) AT=7950.25n

* CHECK dout0_15 Vdout0_15ck158 = 0 time = 7950
.meas tran vdout0_15ck158 FIND v(dout0_15) AT=7950.25n

* CHECK dout0_0 Vdout0_0ck160 = 1.8 time = 8050
.meas tran vdout0_0ck160 FIND v(dout0_0) AT=8050.25n

* CHECK dout0_1 Vdout0_1ck160 = 0 time = 8050
.meas tran vdout0_1ck160 FIND v(dout0_1) AT=8050.25n

* CHECK dout0_2 Vdout0_2ck160 = 0 time = 8050
.meas tran vdout0_2ck160 FIND v(dout0_2) AT=8050.25n

* CHECK dout0_3 Vdout0_3ck160 = 1.8 time = 8050
.meas tran vdout0_3ck160 FIND v(dout0_3) AT=8050.25n

* CHECK dout0_4 Vdout0_4ck160 = 1.8 time = 8050
.meas tran vdout0_4ck160 FIND v(dout0_4) AT=8050.25n

* CHECK dout0_5 Vdout0_5ck160 = 1.8 time = 8050
.meas tran vdout0_5ck160 FIND v(dout0_5) AT=8050.25n

* CHECK dout0_6 Vdout0_6ck160 = 1.8 time = 8050
.meas tran vdout0_6ck160 FIND v(dout0_6) AT=8050.25n

* CHECK dout0_7 Vdout0_7ck160 = 0 time = 8050
.meas tran vdout0_7ck160 FIND v(dout0_7) AT=8050.25n

* CHECK dout0_8 Vdout0_8ck160 = 0 time = 8050
.meas tran vdout0_8ck160 FIND v(dout0_8) AT=8050.25n

* CHECK dout0_9 Vdout0_9ck160 = 1.8 time = 8050
.meas tran vdout0_9ck160 FIND v(dout0_9) AT=8050.25n

* CHECK dout0_10 Vdout0_10ck160 = 1.8 time = 8050
.meas tran vdout0_10ck160 FIND v(dout0_10) AT=8050.25n

* CHECK dout0_11 Vdout0_11ck160 = 0 time = 8050
.meas tran vdout0_11ck160 FIND v(dout0_11) AT=8050.25n

* CHECK dout0_12 Vdout0_12ck160 = 1.8 time = 8050
.meas tran vdout0_12ck160 FIND v(dout0_12) AT=8050.25n

* CHECK dout0_13 Vdout0_13ck160 = 0 time = 8050
.meas tran vdout0_13ck160 FIND v(dout0_13) AT=8050.25n

* CHECK dout0_14 Vdout0_14ck160 = 0 time = 8050
.meas tran vdout0_14ck160 FIND v(dout0_14) AT=8050.25n

* CHECK dout0_15 Vdout0_15ck160 = 0 time = 8050
.meas tran vdout0_15ck160 FIND v(dout0_15) AT=8050.25n

* CHECK dout0_0 Vdout0_0ck162 = 1.8 time = 8150
.meas tran vdout0_0ck162 FIND v(dout0_0) AT=8150.25n

* CHECK dout0_1 Vdout0_1ck162 = 0 time = 8150
.meas tran vdout0_1ck162 FIND v(dout0_1) AT=8150.25n

* CHECK dout0_2 Vdout0_2ck162 = 0 time = 8150
.meas tran vdout0_2ck162 FIND v(dout0_2) AT=8150.25n

* CHECK dout0_3 Vdout0_3ck162 = 1.8 time = 8150
.meas tran vdout0_3ck162 FIND v(dout0_3) AT=8150.25n

* CHECK dout0_4 Vdout0_4ck162 = 1.8 time = 8150
.meas tran vdout0_4ck162 FIND v(dout0_4) AT=8150.25n

* CHECK dout0_5 Vdout0_5ck162 = 1.8 time = 8150
.meas tran vdout0_5ck162 FIND v(dout0_5) AT=8150.25n

* CHECK dout0_6 Vdout0_6ck162 = 1.8 time = 8150
.meas tran vdout0_6ck162 FIND v(dout0_6) AT=8150.25n

* CHECK dout0_7 Vdout0_7ck162 = 0 time = 8150
.meas tran vdout0_7ck162 FIND v(dout0_7) AT=8150.25n

* CHECK dout0_8 Vdout0_8ck162 = 0 time = 8150
.meas tran vdout0_8ck162 FIND v(dout0_8) AT=8150.25n

* CHECK dout0_9 Vdout0_9ck162 = 1.8 time = 8150
.meas tran vdout0_9ck162 FIND v(dout0_9) AT=8150.25n

* CHECK dout0_10 Vdout0_10ck162 = 1.8 time = 8150
.meas tran vdout0_10ck162 FIND v(dout0_10) AT=8150.25n

* CHECK dout0_11 Vdout0_11ck162 = 0 time = 8150
.meas tran vdout0_11ck162 FIND v(dout0_11) AT=8150.25n

* CHECK dout0_12 Vdout0_12ck162 = 1.8 time = 8150
.meas tran vdout0_12ck162 FIND v(dout0_12) AT=8150.25n

* CHECK dout0_13 Vdout0_13ck162 = 0 time = 8150
.meas tran vdout0_13ck162 FIND v(dout0_13) AT=8150.25n

* CHECK dout0_14 Vdout0_14ck162 = 0 time = 8150
.meas tran vdout0_14ck162 FIND v(dout0_14) AT=8150.25n

* CHECK dout0_15 Vdout0_15ck162 = 0 time = 8150
.meas tran vdout0_15ck162 FIND v(dout0_15) AT=8150.25n

* CHECK dout0_0 Vdout0_0ck164 = 0 time = 8250
.meas tran vdout0_0ck164 FIND v(dout0_0) AT=8250.25n

* CHECK dout0_1 Vdout0_1ck164 = 0 time = 8250
.meas tran vdout0_1ck164 FIND v(dout0_1) AT=8250.25n

* CHECK dout0_2 Vdout0_2ck164 = 1.8 time = 8250
.meas tran vdout0_2ck164 FIND v(dout0_2) AT=8250.25n

* CHECK dout0_3 Vdout0_3ck164 = 1.8 time = 8250
.meas tran vdout0_3ck164 FIND v(dout0_3) AT=8250.25n

* CHECK dout0_4 Vdout0_4ck164 = 0 time = 8250
.meas tran vdout0_4ck164 FIND v(dout0_4) AT=8250.25n

* CHECK dout0_5 Vdout0_5ck164 = 1.8 time = 8250
.meas tran vdout0_5ck164 FIND v(dout0_5) AT=8250.25n

* CHECK dout0_6 Vdout0_6ck164 = 1.8 time = 8250
.meas tran vdout0_6ck164 FIND v(dout0_6) AT=8250.25n

* CHECK dout0_7 Vdout0_7ck164 = 0 time = 8250
.meas tran vdout0_7ck164 FIND v(dout0_7) AT=8250.25n

* CHECK dout0_8 Vdout0_8ck164 = 1.8 time = 8250
.meas tran vdout0_8ck164 FIND v(dout0_8) AT=8250.25n

* CHECK dout0_9 Vdout0_9ck164 = 0 time = 8250
.meas tran vdout0_9ck164 FIND v(dout0_9) AT=8250.25n

* CHECK dout0_10 Vdout0_10ck164 = 0 time = 8250
.meas tran vdout0_10ck164 FIND v(dout0_10) AT=8250.25n

* CHECK dout0_11 Vdout0_11ck164 = 1.8 time = 8250
.meas tran vdout0_11ck164 FIND v(dout0_11) AT=8250.25n

* CHECK dout0_12 Vdout0_12ck164 = 1.8 time = 8250
.meas tran vdout0_12ck164 FIND v(dout0_12) AT=8250.25n

* CHECK dout0_13 Vdout0_13ck164 = 1.8 time = 8250
.meas tran vdout0_13ck164 FIND v(dout0_13) AT=8250.25n

* CHECK dout0_14 Vdout0_14ck164 = 0 time = 8250
.meas tran vdout0_14ck164 FIND v(dout0_14) AT=8250.25n

* CHECK dout0_15 Vdout0_15ck164 = 1.8 time = 8250
.meas tran vdout0_15ck164 FIND v(dout0_15) AT=8250.25n

* CHECK dout0_0 Vdout0_0ck165 = 0 time = 8300
.meas tran vdout0_0ck165 FIND v(dout0_0) AT=8300.25n

* CHECK dout0_1 Vdout0_1ck165 = 1.8 time = 8300
.meas tran vdout0_1ck165 FIND v(dout0_1) AT=8300.25n

* CHECK dout0_2 Vdout0_2ck165 = 0 time = 8300
.meas tran vdout0_2ck165 FIND v(dout0_2) AT=8300.25n

* CHECK dout0_3 Vdout0_3ck165 = 1.8 time = 8300
.meas tran vdout0_3ck165 FIND v(dout0_3) AT=8300.25n

* CHECK dout0_4 Vdout0_4ck165 = 1.8 time = 8300
.meas tran vdout0_4ck165 FIND v(dout0_4) AT=8300.25n

* CHECK dout0_5 Vdout0_5ck165 = 1.8 time = 8300
.meas tran vdout0_5ck165 FIND v(dout0_5) AT=8300.25n

* CHECK dout0_6 Vdout0_6ck165 = 1.8 time = 8300
.meas tran vdout0_6ck165 FIND v(dout0_6) AT=8300.25n

* CHECK dout0_7 Vdout0_7ck165 = 0 time = 8300
.meas tran vdout0_7ck165 FIND v(dout0_7) AT=8300.25n

* CHECK dout0_8 Vdout0_8ck165 = 0 time = 8300
.meas tran vdout0_8ck165 FIND v(dout0_8) AT=8300.25n

* CHECK dout0_9 Vdout0_9ck165 = 1.8 time = 8300
.meas tran vdout0_9ck165 FIND v(dout0_9) AT=8300.25n

* CHECK dout0_10 Vdout0_10ck165 = 1.8 time = 8300
.meas tran vdout0_10ck165 FIND v(dout0_10) AT=8300.25n

* CHECK dout0_11 Vdout0_11ck165 = 0 time = 8300
.meas tran vdout0_11ck165 FIND v(dout0_11) AT=8300.25n

* CHECK dout0_12 Vdout0_12ck165 = 0 time = 8300
.meas tran vdout0_12ck165 FIND v(dout0_12) AT=8300.25n

* CHECK dout0_13 Vdout0_13ck165 = 0 time = 8300
.meas tran vdout0_13ck165 FIND v(dout0_13) AT=8300.25n

* CHECK dout0_14 Vdout0_14ck165 = 0 time = 8300
.meas tran vdout0_14ck165 FIND v(dout0_14) AT=8300.25n

* CHECK dout0_15 Vdout0_15ck165 = 1.8 time = 8300
.meas tran vdout0_15ck165 FIND v(dout0_15) AT=8300.25n

* CHECK dout0_0 Vdout0_0ck166 = 1.8 time = 8350
.meas tran vdout0_0ck166 FIND v(dout0_0) AT=8350.25n

* CHECK dout0_1 Vdout0_1ck166 = 0 time = 8350
.meas tran vdout0_1ck166 FIND v(dout0_1) AT=8350.25n

* CHECK dout0_2 Vdout0_2ck166 = 0 time = 8350
.meas tran vdout0_2ck166 FIND v(dout0_2) AT=8350.25n

* CHECK dout0_3 Vdout0_3ck166 = 1.8 time = 8350
.meas tran vdout0_3ck166 FIND v(dout0_3) AT=8350.25n

* CHECK dout0_4 Vdout0_4ck166 = 1.8 time = 8350
.meas tran vdout0_4ck166 FIND v(dout0_4) AT=8350.25n

* CHECK dout0_5 Vdout0_5ck166 = 1.8 time = 8350
.meas tran vdout0_5ck166 FIND v(dout0_5) AT=8350.25n

* CHECK dout0_6 Vdout0_6ck166 = 1.8 time = 8350
.meas tran vdout0_6ck166 FIND v(dout0_6) AT=8350.25n

* CHECK dout0_7 Vdout0_7ck166 = 0 time = 8350
.meas tran vdout0_7ck166 FIND v(dout0_7) AT=8350.25n

* CHECK dout0_8 Vdout0_8ck166 = 0 time = 8350
.meas tran vdout0_8ck166 FIND v(dout0_8) AT=8350.25n

* CHECK dout0_9 Vdout0_9ck166 = 1.8 time = 8350
.meas tran vdout0_9ck166 FIND v(dout0_9) AT=8350.25n

* CHECK dout0_10 Vdout0_10ck166 = 1.8 time = 8350
.meas tran vdout0_10ck166 FIND v(dout0_10) AT=8350.25n

* CHECK dout0_11 Vdout0_11ck166 = 0 time = 8350
.meas tran vdout0_11ck166 FIND v(dout0_11) AT=8350.25n

* CHECK dout0_12 Vdout0_12ck166 = 1.8 time = 8350
.meas tran vdout0_12ck166 FIND v(dout0_12) AT=8350.25n

* CHECK dout0_13 Vdout0_13ck166 = 0 time = 8350
.meas tran vdout0_13ck166 FIND v(dout0_13) AT=8350.25n

* CHECK dout0_14 Vdout0_14ck166 = 0 time = 8350
.meas tran vdout0_14ck166 FIND v(dout0_14) AT=8350.25n

* CHECK dout0_15 Vdout0_15ck166 = 0 time = 8350
.meas tran vdout0_15ck166 FIND v(dout0_15) AT=8350.25n

* CHECK dout0_0 Vdout0_0ck167 = 1.8 time = 8400
.meas tran vdout0_0ck167 FIND v(dout0_0) AT=8400.25n

* CHECK dout0_1 Vdout0_1ck167 = 0 time = 8400
.meas tran vdout0_1ck167 FIND v(dout0_1) AT=8400.25n

* CHECK dout0_2 Vdout0_2ck167 = 0 time = 8400
.meas tran vdout0_2ck167 FIND v(dout0_2) AT=8400.25n

* CHECK dout0_3 Vdout0_3ck167 = 1.8 time = 8400
.meas tran vdout0_3ck167 FIND v(dout0_3) AT=8400.25n

* CHECK dout0_4 Vdout0_4ck167 = 1.8 time = 8400
.meas tran vdout0_4ck167 FIND v(dout0_4) AT=8400.25n

* CHECK dout0_5 Vdout0_5ck167 = 1.8 time = 8400
.meas tran vdout0_5ck167 FIND v(dout0_5) AT=8400.25n

* CHECK dout0_6 Vdout0_6ck167 = 1.8 time = 8400
.meas tran vdout0_6ck167 FIND v(dout0_6) AT=8400.25n

* CHECK dout0_7 Vdout0_7ck167 = 0 time = 8400
.meas tran vdout0_7ck167 FIND v(dout0_7) AT=8400.25n

* CHECK dout0_8 Vdout0_8ck167 = 0 time = 8400
.meas tran vdout0_8ck167 FIND v(dout0_8) AT=8400.25n

* CHECK dout0_9 Vdout0_9ck167 = 1.8 time = 8400
.meas tran vdout0_9ck167 FIND v(dout0_9) AT=8400.25n

* CHECK dout0_10 Vdout0_10ck167 = 1.8 time = 8400
.meas tran vdout0_10ck167 FIND v(dout0_10) AT=8400.25n

* CHECK dout0_11 Vdout0_11ck167 = 0 time = 8400
.meas tran vdout0_11ck167 FIND v(dout0_11) AT=8400.25n

* CHECK dout0_12 Vdout0_12ck167 = 1.8 time = 8400
.meas tran vdout0_12ck167 FIND v(dout0_12) AT=8400.25n

* CHECK dout0_13 Vdout0_13ck167 = 0 time = 8400
.meas tran vdout0_13ck167 FIND v(dout0_13) AT=8400.25n

* CHECK dout0_14 Vdout0_14ck167 = 0 time = 8400
.meas tran vdout0_14ck167 FIND v(dout0_14) AT=8400.25n

* CHECK dout0_15 Vdout0_15ck167 = 0 time = 8400
.meas tran vdout0_15ck167 FIND v(dout0_15) AT=8400.25n

* CHECK dout0_0 Vdout0_0ck170 = 0 time = 8550
.meas tran vdout0_0ck170 FIND v(dout0_0) AT=8550.25n

* CHECK dout0_1 Vdout0_1ck170 = 1.8 time = 8550
.meas tran vdout0_1ck170 FIND v(dout0_1) AT=8550.25n

* CHECK dout0_2 Vdout0_2ck170 = 0 time = 8550
.meas tran vdout0_2ck170 FIND v(dout0_2) AT=8550.25n

* CHECK dout0_3 Vdout0_3ck170 = 0 time = 8550
.meas tran vdout0_3ck170 FIND v(dout0_3) AT=8550.25n

* CHECK dout0_4 Vdout0_4ck170 = 1.8 time = 8550
.meas tran vdout0_4ck170 FIND v(dout0_4) AT=8550.25n

* CHECK dout0_5 Vdout0_5ck170 = 0 time = 8550
.meas tran vdout0_5ck170 FIND v(dout0_5) AT=8550.25n

* CHECK dout0_6 Vdout0_6ck170 = 1.8 time = 8550
.meas tran vdout0_6ck170 FIND v(dout0_6) AT=8550.25n

* CHECK dout0_7 Vdout0_7ck170 = 0 time = 8550
.meas tran vdout0_7ck170 FIND v(dout0_7) AT=8550.25n

* CHECK dout0_8 Vdout0_8ck170 = 0 time = 8550
.meas tran vdout0_8ck170 FIND v(dout0_8) AT=8550.25n

* CHECK dout0_9 Vdout0_9ck170 = 1.8 time = 8550
.meas tran vdout0_9ck170 FIND v(dout0_9) AT=8550.25n

* CHECK dout0_10 Vdout0_10ck170 = 0 time = 8550
.meas tran vdout0_10ck170 FIND v(dout0_10) AT=8550.25n

* CHECK dout0_11 Vdout0_11ck170 = 1.8 time = 8550
.meas tran vdout0_11ck170 FIND v(dout0_11) AT=8550.25n

* CHECK dout0_12 Vdout0_12ck170 = 0 time = 8550
.meas tran vdout0_12ck170 FIND v(dout0_12) AT=8550.25n

* CHECK dout0_13 Vdout0_13ck170 = 1.8 time = 8550
.meas tran vdout0_13ck170 FIND v(dout0_13) AT=8550.25n

* CHECK dout0_14 Vdout0_14ck170 = 0 time = 8550
.meas tran vdout0_14ck170 FIND v(dout0_14) AT=8550.25n

* CHECK dout0_15 Vdout0_15ck170 = 1.8 time = 8550
.meas tran vdout0_15ck170 FIND v(dout0_15) AT=8550.25n

* CHECK dout0_0 Vdout0_0ck171 = 1.8 time = 8600
.meas tran vdout0_0ck171 FIND v(dout0_0) AT=8600.25n

* CHECK dout0_1 Vdout0_1ck171 = 0 time = 8600
.meas tran vdout0_1ck171 FIND v(dout0_1) AT=8600.25n

* CHECK dout0_2 Vdout0_2ck171 = 1.8 time = 8600
.meas tran vdout0_2ck171 FIND v(dout0_2) AT=8600.25n

* CHECK dout0_3 Vdout0_3ck171 = 0 time = 8600
.meas tran vdout0_3ck171 FIND v(dout0_3) AT=8600.25n

* CHECK dout0_4 Vdout0_4ck171 = 1.8 time = 8600
.meas tran vdout0_4ck171 FIND v(dout0_4) AT=8600.25n

* CHECK dout0_5 Vdout0_5ck171 = 1.8 time = 8600
.meas tran vdout0_5ck171 FIND v(dout0_5) AT=8600.25n

* CHECK dout0_6 Vdout0_6ck171 = 1.8 time = 8600
.meas tran vdout0_6ck171 FIND v(dout0_6) AT=8600.25n

* CHECK dout0_7 Vdout0_7ck171 = 0 time = 8600
.meas tran vdout0_7ck171 FIND v(dout0_7) AT=8600.25n

* CHECK dout0_8 Vdout0_8ck171 = 1.8 time = 8600
.meas tran vdout0_8ck171 FIND v(dout0_8) AT=8600.25n

* CHECK dout0_9 Vdout0_9ck171 = 1.8 time = 8600
.meas tran vdout0_9ck171 FIND v(dout0_9) AT=8600.25n

* CHECK dout0_10 Vdout0_10ck171 = 1.8 time = 8600
.meas tran vdout0_10ck171 FIND v(dout0_10) AT=8600.25n

* CHECK dout0_11 Vdout0_11ck171 = 0 time = 8600
.meas tran vdout0_11ck171 FIND v(dout0_11) AT=8600.25n

* CHECK dout0_12 Vdout0_12ck171 = 1.8 time = 8600
.meas tran vdout0_12ck171 FIND v(dout0_12) AT=8600.25n

* CHECK dout0_13 Vdout0_13ck171 = 1.8 time = 8600
.meas tran vdout0_13ck171 FIND v(dout0_13) AT=8600.25n

* CHECK dout0_14 Vdout0_14ck171 = 1.8 time = 8600
.meas tran vdout0_14ck171 FIND v(dout0_14) AT=8600.25n

* CHECK dout0_15 Vdout0_15ck171 = 0 time = 8600
.meas tran vdout0_15ck171 FIND v(dout0_15) AT=8600.25n

* CHECK dout0_0 Vdout0_0ck173 = 1.8 time = 8700
.meas tran vdout0_0ck173 FIND v(dout0_0) AT=8700.25n

* CHECK dout0_1 Vdout0_1ck173 = 1.8 time = 8700
.meas tran vdout0_1ck173 FIND v(dout0_1) AT=8700.25n

* CHECK dout0_2 Vdout0_2ck173 = 0 time = 8700
.meas tran vdout0_2ck173 FIND v(dout0_2) AT=8700.25n

* CHECK dout0_3 Vdout0_3ck173 = 1.8 time = 8700
.meas tran vdout0_3ck173 FIND v(dout0_3) AT=8700.25n

* CHECK dout0_4 Vdout0_4ck173 = 0 time = 8700
.meas tran vdout0_4ck173 FIND v(dout0_4) AT=8700.25n

* CHECK dout0_5 Vdout0_5ck173 = 1.8 time = 8700
.meas tran vdout0_5ck173 FIND v(dout0_5) AT=8700.25n

* CHECK dout0_6 Vdout0_6ck173 = 0 time = 8700
.meas tran vdout0_6ck173 FIND v(dout0_6) AT=8700.25n

* CHECK dout0_7 Vdout0_7ck173 = 1.8 time = 8700
.meas tran vdout0_7ck173 FIND v(dout0_7) AT=8700.25n

* CHECK dout0_8 Vdout0_8ck173 = 1.8 time = 8700
.meas tran vdout0_8ck173 FIND v(dout0_8) AT=8700.25n

* CHECK dout0_9 Vdout0_9ck173 = 0 time = 8700
.meas tran vdout0_9ck173 FIND v(dout0_9) AT=8700.25n

* CHECK dout0_10 Vdout0_10ck173 = 0 time = 8700
.meas tran vdout0_10ck173 FIND v(dout0_10) AT=8700.25n

* CHECK dout0_11 Vdout0_11ck173 = 0 time = 8700
.meas tran vdout0_11ck173 FIND v(dout0_11) AT=8700.25n

* CHECK dout0_12 Vdout0_12ck173 = 1.8 time = 8700
.meas tran vdout0_12ck173 FIND v(dout0_12) AT=8700.25n

* CHECK dout0_13 Vdout0_13ck173 = 0 time = 8700
.meas tran vdout0_13ck173 FIND v(dout0_13) AT=8700.25n

* CHECK dout0_14 Vdout0_14ck173 = 1.8 time = 8700
.meas tran vdout0_14ck173 FIND v(dout0_14) AT=8700.25n

* CHECK dout0_15 Vdout0_15ck173 = 0 time = 8700
.meas tran vdout0_15ck173 FIND v(dout0_15) AT=8700.25n

* CHECK dout0_0 Vdout0_0ck174 = 1.8 time = 8750
.meas tran vdout0_0ck174 FIND v(dout0_0) AT=8750.25n

* CHECK dout0_1 Vdout0_1ck174 = 1.8 time = 8750
.meas tran vdout0_1ck174 FIND v(dout0_1) AT=8750.25n

* CHECK dout0_2 Vdout0_2ck174 = 0 time = 8750
.meas tran vdout0_2ck174 FIND v(dout0_2) AT=8750.25n

* CHECK dout0_3 Vdout0_3ck174 = 1.8 time = 8750
.meas tran vdout0_3ck174 FIND v(dout0_3) AT=8750.25n

* CHECK dout0_4 Vdout0_4ck174 = 0 time = 8750
.meas tran vdout0_4ck174 FIND v(dout0_4) AT=8750.25n

* CHECK dout0_5 Vdout0_5ck174 = 1.8 time = 8750
.meas tran vdout0_5ck174 FIND v(dout0_5) AT=8750.25n

* CHECK dout0_6 Vdout0_6ck174 = 0 time = 8750
.meas tran vdout0_6ck174 FIND v(dout0_6) AT=8750.25n

* CHECK dout0_7 Vdout0_7ck174 = 1.8 time = 8750
.meas tran vdout0_7ck174 FIND v(dout0_7) AT=8750.25n

* CHECK dout0_8 Vdout0_8ck174 = 0 time = 8750
.meas tran vdout0_8ck174 FIND v(dout0_8) AT=8750.25n

* CHECK dout0_9 Vdout0_9ck174 = 1.8 time = 8750
.meas tran vdout0_9ck174 FIND v(dout0_9) AT=8750.25n

* CHECK dout0_10 Vdout0_10ck174 = 0 time = 8750
.meas tran vdout0_10ck174 FIND v(dout0_10) AT=8750.25n

* CHECK dout0_11 Vdout0_11ck174 = 0 time = 8750
.meas tran vdout0_11ck174 FIND v(dout0_11) AT=8750.25n

* CHECK dout0_12 Vdout0_12ck174 = 1.8 time = 8750
.meas tran vdout0_12ck174 FIND v(dout0_12) AT=8750.25n

* CHECK dout0_13 Vdout0_13ck174 = 1.8 time = 8750
.meas tran vdout0_13ck174 FIND v(dout0_13) AT=8750.25n

* CHECK dout0_14 Vdout0_14ck174 = 1.8 time = 8750
.meas tran vdout0_14ck174 FIND v(dout0_14) AT=8750.25n

* CHECK dout0_15 Vdout0_15ck174 = 0 time = 8750
.meas tran vdout0_15ck174 FIND v(dout0_15) AT=8750.25n

* CHECK dout0_0 Vdout0_0ck176 = 1.8 time = 8850
.meas tran vdout0_0ck176 FIND v(dout0_0) AT=8850.25n

* CHECK dout0_1 Vdout0_1ck176 = 1.8 time = 8850
.meas tran vdout0_1ck176 FIND v(dout0_1) AT=8850.25n

* CHECK dout0_2 Vdout0_2ck176 = 0 time = 8850
.meas tran vdout0_2ck176 FIND v(dout0_2) AT=8850.25n

* CHECK dout0_3 Vdout0_3ck176 = 1.8 time = 8850
.meas tran vdout0_3ck176 FIND v(dout0_3) AT=8850.25n

* CHECK dout0_4 Vdout0_4ck176 = 0 time = 8850
.meas tran vdout0_4ck176 FIND v(dout0_4) AT=8850.25n

* CHECK dout0_5 Vdout0_5ck176 = 1.8 time = 8850
.meas tran vdout0_5ck176 FIND v(dout0_5) AT=8850.25n

* CHECK dout0_6 Vdout0_6ck176 = 0 time = 8850
.meas tran vdout0_6ck176 FIND v(dout0_6) AT=8850.25n

* CHECK dout0_7 Vdout0_7ck176 = 1.8 time = 8850
.meas tran vdout0_7ck176 FIND v(dout0_7) AT=8850.25n

* CHECK dout0_8 Vdout0_8ck176 = 1.8 time = 8850
.meas tran vdout0_8ck176 FIND v(dout0_8) AT=8850.25n

* CHECK dout0_9 Vdout0_9ck176 = 0 time = 8850
.meas tran vdout0_9ck176 FIND v(dout0_9) AT=8850.25n

* CHECK dout0_10 Vdout0_10ck176 = 0 time = 8850
.meas tran vdout0_10ck176 FIND v(dout0_10) AT=8850.25n

* CHECK dout0_11 Vdout0_11ck176 = 0 time = 8850
.meas tran vdout0_11ck176 FIND v(dout0_11) AT=8850.25n

* CHECK dout0_12 Vdout0_12ck176 = 1.8 time = 8850
.meas tran vdout0_12ck176 FIND v(dout0_12) AT=8850.25n

* CHECK dout0_13 Vdout0_13ck176 = 0 time = 8850
.meas tran vdout0_13ck176 FIND v(dout0_13) AT=8850.25n

* CHECK dout0_14 Vdout0_14ck176 = 1.8 time = 8850
.meas tran vdout0_14ck176 FIND v(dout0_14) AT=8850.25n

* CHECK dout0_15 Vdout0_15ck176 = 0 time = 8850
.meas tran vdout0_15ck176 FIND v(dout0_15) AT=8850.25n

* CHECK dout0_0 Vdout0_0ck177 = 1.8 time = 8900
.meas tran vdout0_0ck177 FIND v(dout0_0) AT=8900.25n

* CHECK dout0_1 Vdout0_1ck177 = 1.8 time = 8900
.meas tran vdout0_1ck177 FIND v(dout0_1) AT=8900.25n

* CHECK dout0_2 Vdout0_2ck177 = 0 time = 8900
.meas tran vdout0_2ck177 FIND v(dout0_2) AT=8900.25n

* CHECK dout0_3 Vdout0_3ck177 = 1.8 time = 8900
.meas tran vdout0_3ck177 FIND v(dout0_3) AT=8900.25n

* CHECK dout0_4 Vdout0_4ck177 = 0 time = 8900
.meas tran vdout0_4ck177 FIND v(dout0_4) AT=8900.25n

* CHECK dout0_5 Vdout0_5ck177 = 1.8 time = 8900
.meas tran vdout0_5ck177 FIND v(dout0_5) AT=8900.25n

* CHECK dout0_6 Vdout0_6ck177 = 0 time = 8900
.meas tran vdout0_6ck177 FIND v(dout0_6) AT=8900.25n

* CHECK dout0_7 Vdout0_7ck177 = 1.8 time = 8900
.meas tran vdout0_7ck177 FIND v(dout0_7) AT=8900.25n

* CHECK dout0_8 Vdout0_8ck177 = 0 time = 8900
.meas tran vdout0_8ck177 FIND v(dout0_8) AT=8900.25n

* CHECK dout0_9 Vdout0_9ck177 = 1.8 time = 8900
.meas tran vdout0_9ck177 FIND v(dout0_9) AT=8900.25n

* CHECK dout0_10 Vdout0_10ck177 = 0 time = 8900
.meas tran vdout0_10ck177 FIND v(dout0_10) AT=8900.25n

* CHECK dout0_11 Vdout0_11ck177 = 0 time = 8900
.meas tran vdout0_11ck177 FIND v(dout0_11) AT=8900.25n

* CHECK dout0_12 Vdout0_12ck177 = 1.8 time = 8900
.meas tran vdout0_12ck177 FIND v(dout0_12) AT=8900.25n

* CHECK dout0_13 Vdout0_13ck177 = 1.8 time = 8900
.meas tran vdout0_13ck177 FIND v(dout0_13) AT=8900.25n

* CHECK dout0_14 Vdout0_14ck177 = 1.8 time = 8900
.meas tran vdout0_14ck177 FIND v(dout0_14) AT=8900.25n

* CHECK dout0_15 Vdout0_15ck177 = 0 time = 8900
.meas tran vdout0_15ck177 FIND v(dout0_15) AT=8900.25n

* CHECK dout0_0 Vdout0_0ck179 = 0 time = 9000
.meas tran vdout0_0ck179 FIND v(dout0_0) AT=9000.25n

* CHECK dout0_1 Vdout0_1ck179 = 0 time = 9000
.meas tran vdout0_1ck179 FIND v(dout0_1) AT=9000.25n

* CHECK dout0_2 Vdout0_2ck179 = 0 time = 9000
.meas tran vdout0_2ck179 FIND v(dout0_2) AT=9000.25n

* CHECK dout0_3 Vdout0_3ck179 = 1.8 time = 9000
.meas tran vdout0_3ck179 FIND v(dout0_3) AT=9000.25n

* CHECK dout0_4 Vdout0_4ck179 = 1.8 time = 9000
.meas tran vdout0_4ck179 FIND v(dout0_4) AT=9000.25n

* CHECK dout0_5 Vdout0_5ck179 = 1.8 time = 9000
.meas tran vdout0_5ck179 FIND v(dout0_5) AT=9000.25n

* CHECK dout0_6 Vdout0_6ck179 = 0 time = 9000
.meas tran vdout0_6ck179 FIND v(dout0_6) AT=9000.25n

* CHECK dout0_7 Vdout0_7ck179 = 0 time = 9000
.meas tran vdout0_7ck179 FIND v(dout0_7) AT=9000.25n

* CHECK dout0_8 Vdout0_8ck179 = 1.8 time = 9000
.meas tran vdout0_8ck179 FIND v(dout0_8) AT=9000.25n

* CHECK dout0_9 Vdout0_9ck179 = 1.8 time = 9000
.meas tran vdout0_9ck179 FIND v(dout0_9) AT=9000.25n

* CHECK dout0_10 Vdout0_10ck179 = 1.8 time = 9000
.meas tran vdout0_10ck179 FIND v(dout0_10) AT=9000.25n

* CHECK dout0_11 Vdout0_11ck179 = 1.8 time = 9000
.meas tran vdout0_11ck179 FIND v(dout0_11) AT=9000.25n

* CHECK dout0_12 Vdout0_12ck179 = 0 time = 9000
.meas tran vdout0_12ck179 FIND v(dout0_12) AT=9000.25n

* CHECK dout0_13 Vdout0_13ck179 = 0 time = 9000
.meas tran vdout0_13ck179 FIND v(dout0_13) AT=9000.25n

* CHECK dout0_14 Vdout0_14ck179 = 0 time = 9000
.meas tran vdout0_14ck179 FIND v(dout0_14) AT=9000.25n

* CHECK dout0_15 Vdout0_15ck179 = 1.8 time = 9000
.meas tran vdout0_15ck179 FIND v(dout0_15) AT=9000.25n

* CHECK dout0_0 Vdout0_0ck183 = 1.8 time = 9200
.meas tran vdout0_0ck183 FIND v(dout0_0) AT=9200.25n

* CHECK dout0_1 Vdout0_1ck183 = 1.8 time = 9200
.meas tran vdout0_1ck183 FIND v(dout0_1) AT=9200.25n

* CHECK dout0_2 Vdout0_2ck183 = 0 time = 9200
.meas tran vdout0_2ck183 FIND v(dout0_2) AT=9200.25n

* CHECK dout0_3 Vdout0_3ck183 = 1.8 time = 9200
.meas tran vdout0_3ck183 FIND v(dout0_3) AT=9200.25n

* CHECK dout0_4 Vdout0_4ck183 = 0 time = 9200
.meas tran vdout0_4ck183 FIND v(dout0_4) AT=9200.25n

* CHECK dout0_5 Vdout0_5ck183 = 1.8 time = 9200
.meas tran vdout0_5ck183 FIND v(dout0_5) AT=9200.25n

* CHECK dout0_6 Vdout0_6ck183 = 0 time = 9200
.meas tran vdout0_6ck183 FIND v(dout0_6) AT=9200.25n

* CHECK dout0_7 Vdout0_7ck183 = 1.8 time = 9200
.meas tran vdout0_7ck183 FIND v(dout0_7) AT=9200.25n

* CHECK dout0_8 Vdout0_8ck183 = 1.8 time = 9200
.meas tran vdout0_8ck183 FIND v(dout0_8) AT=9200.25n

* CHECK dout0_9 Vdout0_9ck183 = 0 time = 9200
.meas tran vdout0_9ck183 FIND v(dout0_9) AT=9200.25n

* CHECK dout0_10 Vdout0_10ck183 = 0 time = 9200
.meas tran vdout0_10ck183 FIND v(dout0_10) AT=9200.25n

* CHECK dout0_11 Vdout0_11ck183 = 0 time = 9200
.meas tran vdout0_11ck183 FIND v(dout0_11) AT=9200.25n

* CHECK dout0_12 Vdout0_12ck183 = 1.8 time = 9200
.meas tran vdout0_12ck183 FIND v(dout0_12) AT=9200.25n

* CHECK dout0_13 Vdout0_13ck183 = 0 time = 9200
.meas tran vdout0_13ck183 FIND v(dout0_13) AT=9200.25n

* CHECK dout0_14 Vdout0_14ck183 = 1.8 time = 9200
.meas tran vdout0_14ck183 FIND v(dout0_14) AT=9200.25n

* CHECK dout0_15 Vdout0_15ck183 = 0 time = 9200
.meas tran vdout0_15ck183 FIND v(dout0_15) AT=9200.25n

* CHECK dout0_0 Vdout0_0ck184 = 0 time = 9250
.meas tran vdout0_0ck184 FIND v(dout0_0) AT=9250.25n

* CHECK dout0_1 Vdout0_1ck184 = 1.8 time = 9250
.meas tran vdout0_1ck184 FIND v(dout0_1) AT=9250.25n

* CHECK dout0_2 Vdout0_2ck184 = 0 time = 9250
.meas tran vdout0_2ck184 FIND v(dout0_2) AT=9250.25n

* CHECK dout0_3 Vdout0_3ck184 = 0 time = 9250
.meas tran vdout0_3ck184 FIND v(dout0_3) AT=9250.25n

* CHECK dout0_4 Vdout0_4ck184 = 1.8 time = 9250
.meas tran vdout0_4ck184 FIND v(dout0_4) AT=9250.25n

* CHECK dout0_5 Vdout0_5ck184 = 0 time = 9250
.meas tran vdout0_5ck184 FIND v(dout0_5) AT=9250.25n

* CHECK dout0_6 Vdout0_6ck184 = 1.8 time = 9250
.meas tran vdout0_6ck184 FIND v(dout0_6) AT=9250.25n

* CHECK dout0_7 Vdout0_7ck184 = 0 time = 9250
.meas tran vdout0_7ck184 FIND v(dout0_7) AT=9250.25n

* CHECK dout0_8 Vdout0_8ck184 = 0 time = 9250
.meas tran vdout0_8ck184 FIND v(dout0_8) AT=9250.25n

* CHECK dout0_9 Vdout0_9ck184 = 1.8 time = 9250
.meas tran vdout0_9ck184 FIND v(dout0_9) AT=9250.25n

* CHECK dout0_10 Vdout0_10ck184 = 0 time = 9250
.meas tran vdout0_10ck184 FIND v(dout0_10) AT=9250.25n

* CHECK dout0_11 Vdout0_11ck184 = 1.8 time = 9250
.meas tran vdout0_11ck184 FIND v(dout0_11) AT=9250.25n

* CHECK dout0_12 Vdout0_12ck184 = 0 time = 9250
.meas tran vdout0_12ck184 FIND v(dout0_12) AT=9250.25n

* CHECK dout0_13 Vdout0_13ck184 = 1.8 time = 9250
.meas tran vdout0_13ck184 FIND v(dout0_13) AT=9250.25n

* CHECK dout0_14 Vdout0_14ck184 = 0 time = 9250
.meas tran vdout0_14ck184 FIND v(dout0_14) AT=9250.25n

* CHECK dout0_15 Vdout0_15ck184 = 1.8 time = 9250
.meas tran vdout0_15ck184 FIND v(dout0_15) AT=9250.25n

* CHECK dout0_0 Vdout0_0ck185 = 1.8 time = 9300
.meas tran vdout0_0ck185 FIND v(dout0_0) AT=9300.25n

* CHECK dout0_1 Vdout0_1ck185 = 1.8 time = 9300
.meas tran vdout0_1ck185 FIND v(dout0_1) AT=9300.25n

* CHECK dout0_2 Vdout0_2ck185 = 1.8 time = 9300
.meas tran vdout0_2ck185 FIND v(dout0_2) AT=9300.25n

* CHECK dout0_3 Vdout0_3ck185 = 0 time = 9300
.meas tran vdout0_3ck185 FIND v(dout0_3) AT=9300.25n

* CHECK dout0_4 Vdout0_4ck185 = 0 time = 9300
.meas tran vdout0_4ck185 FIND v(dout0_4) AT=9300.25n

* CHECK dout0_5 Vdout0_5ck185 = 0 time = 9300
.meas tran vdout0_5ck185 FIND v(dout0_5) AT=9300.25n

* CHECK dout0_6 Vdout0_6ck185 = 0 time = 9300
.meas tran vdout0_6ck185 FIND v(dout0_6) AT=9300.25n

* CHECK dout0_7 Vdout0_7ck185 = 0 time = 9300
.meas tran vdout0_7ck185 FIND v(dout0_7) AT=9300.25n

* CHECK dout0_8 Vdout0_8ck185 = 0 time = 9300
.meas tran vdout0_8ck185 FIND v(dout0_8) AT=9300.25n

* CHECK dout0_9 Vdout0_9ck185 = 0 time = 9300
.meas tran vdout0_9ck185 FIND v(dout0_9) AT=9300.25n

* CHECK dout0_10 Vdout0_10ck185 = 0 time = 9300
.meas tran vdout0_10ck185 FIND v(dout0_10) AT=9300.25n

* CHECK dout0_11 Vdout0_11ck185 = 0 time = 9300
.meas tran vdout0_11ck185 FIND v(dout0_11) AT=9300.25n

* CHECK dout0_12 Vdout0_12ck185 = 0 time = 9300
.meas tran vdout0_12ck185 FIND v(dout0_12) AT=9300.25n

* CHECK dout0_13 Vdout0_13ck185 = 1.8 time = 9300
.meas tran vdout0_13ck185 FIND v(dout0_13) AT=9300.25n

* CHECK dout0_14 Vdout0_14ck185 = 0 time = 9300
.meas tran vdout0_14ck185 FIND v(dout0_14) AT=9300.25n

* CHECK dout0_15 Vdout0_15ck185 = 1.8 time = 9300
.meas tran vdout0_15ck185 FIND v(dout0_15) AT=9300.25n

* CHECK dout0_0 Vdout0_0ck186 = 1.8 time = 9350
.meas tran vdout0_0ck186 FIND v(dout0_0) AT=9350.25n

* CHECK dout0_1 Vdout0_1ck186 = 1.8 time = 9350
.meas tran vdout0_1ck186 FIND v(dout0_1) AT=9350.25n

* CHECK dout0_2 Vdout0_2ck186 = 0 time = 9350
.meas tran vdout0_2ck186 FIND v(dout0_2) AT=9350.25n

* CHECK dout0_3 Vdout0_3ck186 = 1.8 time = 9350
.meas tran vdout0_3ck186 FIND v(dout0_3) AT=9350.25n

* CHECK dout0_4 Vdout0_4ck186 = 0 time = 9350
.meas tran vdout0_4ck186 FIND v(dout0_4) AT=9350.25n

* CHECK dout0_5 Vdout0_5ck186 = 1.8 time = 9350
.meas tran vdout0_5ck186 FIND v(dout0_5) AT=9350.25n

* CHECK dout0_6 Vdout0_6ck186 = 0 time = 9350
.meas tran vdout0_6ck186 FIND v(dout0_6) AT=9350.25n

* CHECK dout0_7 Vdout0_7ck186 = 1.8 time = 9350
.meas tran vdout0_7ck186 FIND v(dout0_7) AT=9350.25n

* CHECK dout0_8 Vdout0_8ck186 = 1.8 time = 9350
.meas tran vdout0_8ck186 FIND v(dout0_8) AT=9350.25n

* CHECK dout0_9 Vdout0_9ck186 = 0 time = 9350
.meas tran vdout0_9ck186 FIND v(dout0_9) AT=9350.25n

* CHECK dout0_10 Vdout0_10ck186 = 0 time = 9350
.meas tran vdout0_10ck186 FIND v(dout0_10) AT=9350.25n

* CHECK dout0_11 Vdout0_11ck186 = 0 time = 9350
.meas tran vdout0_11ck186 FIND v(dout0_11) AT=9350.25n

* CHECK dout0_12 Vdout0_12ck186 = 1.8 time = 9350
.meas tran vdout0_12ck186 FIND v(dout0_12) AT=9350.25n

* CHECK dout0_13 Vdout0_13ck186 = 0 time = 9350
.meas tran vdout0_13ck186 FIND v(dout0_13) AT=9350.25n

* CHECK dout0_14 Vdout0_14ck186 = 1.8 time = 9350
.meas tran vdout0_14ck186 FIND v(dout0_14) AT=9350.25n

* CHECK dout0_15 Vdout0_15ck186 = 0 time = 9350
.meas tran vdout0_15ck186 FIND v(dout0_15) AT=9350.25n

* CHECK dout0_0 Vdout0_0ck190 = 0 time = 9550
.meas tran vdout0_0ck190 FIND v(dout0_0) AT=9550.25n

* CHECK dout0_1 Vdout0_1ck190 = 0 time = 9550
.meas tran vdout0_1ck190 FIND v(dout0_1) AT=9550.25n

* CHECK dout0_2 Vdout0_2ck190 = 1.8 time = 9550
.meas tran vdout0_2ck190 FIND v(dout0_2) AT=9550.25n

* CHECK dout0_3 Vdout0_3ck190 = 0 time = 9550
.meas tran vdout0_3ck190 FIND v(dout0_3) AT=9550.25n

* CHECK dout0_4 Vdout0_4ck190 = 0 time = 9550
.meas tran vdout0_4ck190 FIND v(dout0_4) AT=9550.25n

* CHECK dout0_5 Vdout0_5ck190 = 1.8 time = 9550
.meas tran vdout0_5ck190 FIND v(dout0_5) AT=9550.25n

* CHECK dout0_6 Vdout0_6ck190 = 0 time = 9550
.meas tran vdout0_6ck190 FIND v(dout0_6) AT=9550.25n

* CHECK dout0_7 Vdout0_7ck190 = 0 time = 9550
.meas tran vdout0_7ck190 FIND v(dout0_7) AT=9550.25n

* CHECK dout0_8 Vdout0_8ck190 = 0 time = 9550
.meas tran vdout0_8ck190 FIND v(dout0_8) AT=9550.25n

* CHECK dout0_9 Vdout0_9ck190 = 0 time = 9550
.meas tran vdout0_9ck190 FIND v(dout0_9) AT=9550.25n

* CHECK dout0_10 Vdout0_10ck190 = 0 time = 9550
.meas tran vdout0_10ck190 FIND v(dout0_10) AT=9550.25n

* CHECK dout0_11 Vdout0_11ck190 = 1.8 time = 9550
.meas tran vdout0_11ck190 FIND v(dout0_11) AT=9550.25n

* CHECK dout0_12 Vdout0_12ck190 = 1.8 time = 9550
.meas tran vdout0_12ck190 FIND v(dout0_12) AT=9550.25n

* CHECK dout0_13 Vdout0_13ck190 = 0 time = 9550
.meas tran vdout0_13ck190 FIND v(dout0_13) AT=9550.25n

* CHECK dout0_14 Vdout0_14ck190 = 0 time = 9550
.meas tran vdout0_14ck190 FIND v(dout0_14) AT=9550.25n

* CHECK dout0_15 Vdout0_15ck190 = 1.8 time = 9550
.meas tran vdout0_15ck190 FIND v(dout0_15) AT=9550.25n

* CHECK dout0_0 Vdout0_0ck191 = 1.8 time = 9600
.meas tran vdout0_0ck191 FIND v(dout0_0) AT=9600.25n

* CHECK dout0_1 Vdout0_1ck191 = 0 time = 9600
.meas tran vdout0_1ck191 FIND v(dout0_1) AT=9600.25n

* CHECK dout0_2 Vdout0_2ck191 = 1.8 time = 9600
.meas tran vdout0_2ck191 FIND v(dout0_2) AT=9600.25n

* CHECK dout0_3 Vdout0_3ck191 = 0 time = 9600
.meas tran vdout0_3ck191 FIND v(dout0_3) AT=9600.25n

* CHECK dout0_4 Vdout0_4ck191 = 0 time = 9600
.meas tran vdout0_4ck191 FIND v(dout0_4) AT=9600.25n

* CHECK dout0_5 Vdout0_5ck191 = 1.8 time = 9600
.meas tran vdout0_5ck191 FIND v(dout0_5) AT=9600.25n

* CHECK dout0_6 Vdout0_6ck191 = 0 time = 9600
.meas tran vdout0_6ck191 FIND v(dout0_6) AT=9600.25n

* CHECK dout0_7 Vdout0_7ck191 = 1.8 time = 9600
.meas tran vdout0_7ck191 FIND v(dout0_7) AT=9600.25n

* CHECK dout0_8 Vdout0_8ck191 = 1.8 time = 9600
.meas tran vdout0_8ck191 FIND v(dout0_8) AT=9600.25n

* CHECK dout0_9 Vdout0_9ck191 = 1.8 time = 9600
.meas tran vdout0_9ck191 FIND v(dout0_9) AT=9600.25n

* CHECK dout0_10 Vdout0_10ck191 = 1.8 time = 9600
.meas tran vdout0_10ck191 FIND v(dout0_10) AT=9600.25n

* CHECK dout0_11 Vdout0_11ck191 = 0 time = 9600
.meas tran vdout0_11ck191 FIND v(dout0_11) AT=9600.25n

* CHECK dout0_12 Vdout0_12ck191 = 0 time = 9600
.meas tran vdout0_12ck191 FIND v(dout0_12) AT=9600.25n

* CHECK dout0_13 Vdout0_13ck191 = 0 time = 9600
.meas tran vdout0_13ck191 FIND v(dout0_13) AT=9600.25n

* CHECK dout0_14 Vdout0_14ck191 = 0 time = 9600
.meas tran vdout0_14ck191 FIND v(dout0_14) AT=9600.25n

* CHECK dout0_15 Vdout0_15ck191 = 1.8 time = 9600
.meas tran vdout0_15ck191 FIND v(dout0_15) AT=9600.25n

* CHECK dout0_0 Vdout0_0ck194 = 1.8 time = 9750
.meas tran vdout0_0ck194 FIND v(dout0_0) AT=9750.25n

* CHECK dout0_1 Vdout0_1ck194 = 0 time = 9750
.meas tran vdout0_1ck194 FIND v(dout0_1) AT=9750.25n

* CHECK dout0_2 Vdout0_2ck194 = 1.8 time = 9750
.meas tran vdout0_2ck194 FIND v(dout0_2) AT=9750.25n

* CHECK dout0_3 Vdout0_3ck194 = 0 time = 9750
.meas tran vdout0_3ck194 FIND v(dout0_3) AT=9750.25n

* CHECK dout0_4 Vdout0_4ck194 = 0 time = 9750
.meas tran vdout0_4ck194 FIND v(dout0_4) AT=9750.25n

* CHECK dout0_5 Vdout0_5ck194 = 1.8 time = 9750
.meas tran vdout0_5ck194 FIND v(dout0_5) AT=9750.25n

* CHECK dout0_6 Vdout0_6ck194 = 0 time = 9750
.meas tran vdout0_6ck194 FIND v(dout0_6) AT=9750.25n

* CHECK dout0_7 Vdout0_7ck194 = 1.8 time = 9750
.meas tran vdout0_7ck194 FIND v(dout0_7) AT=9750.25n

* CHECK dout0_8 Vdout0_8ck194 = 1.8 time = 9750
.meas tran vdout0_8ck194 FIND v(dout0_8) AT=9750.25n

* CHECK dout0_9 Vdout0_9ck194 = 1.8 time = 9750
.meas tran vdout0_9ck194 FIND v(dout0_9) AT=9750.25n

* CHECK dout0_10 Vdout0_10ck194 = 1.8 time = 9750
.meas tran vdout0_10ck194 FIND v(dout0_10) AT=9750.25n

* CHECK dout0_11 Vdout0_11ck194 = 0 time = 9750
.meas tran vdout0_11ck194 FIND v(dout0_11) AT=9750.25n

* CHECK dout0_12 Vdout0_12ck194 = 0 time = 9750
.meas tran vdout0_12ck194 FIND v(dout0_12) AT=9750.25n

* CHECK dout0_13 Vdout0_13ck194 = 0 time = 9750
.meas tran vdout0_13ck194 FIND v(dout0_13) AT=9750.25n

* CHECK dout0_14 Vdout0_14ck194 = 0 time = 9750
.meas tran vdout0_14ck194 FIND v(dout0_14) AT=9750.25n

* CHECK dout0_15 Vdout0_15ck194 = 1.8 time = 9750
.meas tran vdout0_15ck194 FIND v(dout0_15) AT=9750.25n

* CHECK dout0_0 Vdout0_0ck195 = 0 time = 9800
.meas tran vdout0_0ck195 FIND v(dout0_0) AT=9800.25n

* CHECK dout0_1 Vdout0_1ck195 = 0 time = 9800
.meas tran vdout0_1ck195 FIND v(dout0_1) AT=9800.25n

* CHECK dout0_2 Vdout0_2ck195 = 0 time = 9800
.meas tran vdout0_2ck195 FIND v(dout0_2) AT=9800.25n

* CHECK dout0_3 Vdout0_3ck195 = 0 time = 9800
.meas tran vdout0_3ck195 FIND v(dout0_3) AT=9800.25n

* CHECK dout0_4 Vdout0_4ck195 = 1.8 time = 9800
.meas tran vdout0_4ck195 FIND v(dout0_4) AT=9800.25n

* CHECK dout0_5 Vdout0_5ck195 = 1.8 time = 9800
.meas tran vdout0_5ck195 FIND v(dout0_5) AT=9800.25n

* CHECK dout0_6 Vdout0_6ck195 = 0 time = 9800
.meas tran vdout0_6ck195 FIND v(dout0_6) AT=9800.25n

* CHECK dout0_7 Vdout0_7ck195 = 1.8 time = 9800
.meas tran vdout0_7ck195 FIND v(dout0_7) AT=9800.25n

* CHECK dout0_8 Vdout0_8ck195 = 1.8 time = 9800
.meas tran vdout0_8ck195 FIND v(dout0_8) AT=9800.25n

* CHECK dout0_9 Vdout0_9ck195 = 0 time = 9800
.meas tran vdout0_9ck195 FIND v(dout0_9) AT=9800.25n

* CHECK dout0_10 Vdout0_10ck195 = 0 time = 9800
.meas tran vdout0_10ck195 FIND v(dout0_10) AT=9800.25n

* CHECK dout0_11 Vdout0_11ck195 = 0 time = 9800
.meas tran vdout0_11ck195 FIND v(dout0_11) AT=9800.25n

* CHECK dout0_12 Vdout0_12ck195 = 1.8 time = 9800
.meas tran vdout0_12ck195 FIND v(dout0_12) AT=9800.25n

* CHECK dout0_13 Vdout0_13ck195 = 0 time = 9800
.meas tran vdout0_13ck195 FIND v(dout0_13) AT=9800.25n

* CHECK dout0_14 Vdout0_14ck195 = 0 time = 9800
.meas tran vdout0_14ck195 FIND v(dout0_14) AT=9800.25n

* CHECK dout0_15 Vdout0_15ck195 = 0 time = 9800
.meas tran vdout0_15ck195 FIND v(dout0_15) AT=9800.25n

* CHECK dout0_0 Vdout0_0ck196 = 1.8 time = 9850
.meas tran vdout0_0ck196 FIND v(dout0_0) AT=9850.25n

* CHECK dout0_1 Vdout0_1ck196 = 0 time = 9850
.meas tran vdout0_1ck196 FIND v(dout0_1) AT=9850.25n

* CHECK dout0_2 Vdout0_2ck196 = 1.8 time = 9850
.meas tran vdout0_2ck196 FIND v(dout0_2) AT=9850.25n

* CHECK dout0_3 Vdout0_3ck196 = 0 time = 9850
.meas tran vdout0_3ck196 FIND v(dout0_3) AT=9850.25n

* CHECK dout0_4 Vdout0_4ck196 = 0 time = 9850
.meas tran vdout0_4ck196 FIND v(dout0_4) AT=9850.25n

* CHECK dout0_5 Vdout0_5ck196 = 0 time = 9850
.meas tran vdout0_5ck196 FIND v(dout0_5) AT=9850.25n

* CHECK dout0_6 Vdout0_6ck196 = 0 time = 9850
.meas tran vdout0_6ck196 FIND v(dout0_6) AT=9850.25n

* CHECK dout0_7 Vdout0_7ck196 = 1.8 time = 9850
.meas tran vdout0_7ck196 FIND v(dout0_7) AT=9850.25n

* CHECK dout0_8 Vdout0_8ck196 = 0 time = 9850
.meas tran vdout0_8ck196 FIND v(dout0_8) AT=9850.25n

* CHECK dout0_9 Vdout0_9ck196 = 0 time = 9850
.meas tran vdout0_9ck196 FIND v(dout0_9) AT=9850.25n

* CHECK dout0_10 Vdout0_10ck196 = 0 time = 9850
.meas tran vdout0_10ck196 FIND v(dout0_10) AT=9850.25n

* CHECK dout0_11 Vdout0_11ck196 = 1.8 time = 9850
.meas tran vdout0_11ck196 FIND v(dout0_11) AT=9850.25n

* CHECK dout0_12 Vdout0_12ck196 = 0 time = 9850
.meas tran vdout0_12ck196 FIND v(dout0_12) AT=9850.25n

* CHECK dout0_13 Vdout0_13ck196 = 0 time = 9850
.meas tran vdout0_13ck196 FIND v(dout0_13) AT=9850.25n

* CHECK dout0_14 Vdout0_14ck196 = 1.8 time = 9850
.meas tran vdout0_14ck196 FIND v(dout0_14) AT=9850.25n

* CHECK dout0_15 Vdout0_15ck196 = 0 time = 9850
.meas tran vdout0_15ck196 FIND v(dout0_15) AT=9850.25n

* CHECK dout0_0 Vdout0_0ck197 = 0 time = 9900
.meas tran vdout0_0ck197 FIND v(dout0_0) AT=9900.25n

* CHECK dout0_1 Vdout0_1ck197 = 1.8 time = 9900
.meas tran vdout0_1ck197 FIND v(dout0_1) AT=9900.25n

* CHECK dout0_2 Vdout0_2ck197 = 0 time = 9900
.meas tran vdout0_2ck197 FIND v(dout0_2) AT=9900.25n

* CHECK dout0_3 Vdout0_3ck197 = 0 time = 9900
.meas tran vdout0_3ck197 FIND v(dout0_3) AT=9900.25n

* CHECK dout0_4 Vdout0_4ck197 = 1.8 time = 9900
.meas tran vdout0_4ck197 FIND v(dout0_4) AT=9900.25n

* CHECK dout0_5 Vdout0_5ck197 = 0 time = 9900
.meas tran vdout0_5ck197 FIND v(dout0_5) AT=9900.25n

* CHECK dout0_6 Vdout0_6ck197 = 1.8 time = 9900
.meas tran vdout0_6ck197 FIND v(dout0_6) AT=9900.25n

* CHECK dout0_7 Vdout0_7ck197 = 0 time = 9900
.meas tran vdout0_7ck197 FIND v(dout0_7) AT=9900.25n

* CHECK dout0_8 Vdout0_8ck197 = 0 time = 9900
.meas tran vdout0_8ck197 FIND v(dout0_8) AT=9900.25n

* CHECK dout0_9 Vdout0_9ck197 = 1.8 time = 9900
.meas tran vdout0_9ck197 FIND v(dout0_9) AT=9900.25n

* CHECK dout0_10 Vdout0_10ck197 = 0 time = 9900
.meas tran vdout0_10ck197 FIND v(dout0_10) AT=9900.25n

* CHECK dout0_11 Vdout0_11ck197 = 1.8 time = 9900
.meas tran vdout0_11ck197 FIND v(dout0_11) AT=9900.25n

* CHECK dout0_12 Vdout0_12ck197 = 0 time = 9900
.meas tran vdout0_12ck197 FIND v(dout0_12) AT=9900.25n

* CHECK dout0_13 Vdout0_13ck197 = 1.8 time = 9900
.meas tran vdout0_13ck197 FIND v(dout0_13) AT=9900.25n

* CHECK dout0_14 Vdout0_14ck197 = 0 time = 9900
.meas tran vdout0_14ck197 FIND v(dout0_14) AT=9900.25n

* CHECK dout0_15 Vdout0_15ck197 = 1.8 time = 9900
.meas tran vdout0_15ck197 FIND v(dout0_15) AT=9900.25n

* CHECK dout0_0 Vdout0_0ck198 = 1.8 time = 9950
.meas tran vdout0_0ck198 FIND v(dout0_0) AT=9950.25n

* CHECK dout0_1 Vdout0_1ck198 = 1.8 time = 9950
.meas tran vdout0_1ck198 FIND v(dout0_1) AT=9950.25n

* CHECK dout0_2 Vdout0_2ck198 = 0 time = 9950
.meas tran vdout0_2ck198 FIND v(dout0_2) AT=9950.25n

* CHECK dout0_3 Vdout0_3ck198 = 1.8 time = 9950
.meas tran vdout0_3ck198 FIND v(dout0_3) AT=9950.25n

* CHECK dout0_4 Vdout0_4ck198 = 1.8 time = 9950
.meas tran vdout0_4ck198 FIND v(dout0_4) AT=9950.25n

* CHECK dout0_5 Vdout0_5ck198 = 0 time = 9950
.meas tran vdout0_5ck198 FIND v(dout0_5) AT=9950.25n

* CHECK dout0_6 Vdout0_6ck198 = 1.8 time = 9950
.meas tran vdout0_6ck198 FIND v(dout0_6) AT=9950.25n

* CHECK dout0_7 Vdout0_7ck198 = 1.8 time = 9950
.meas tran vdout0_7ck198 FIND v(dout0_7) AT=9950.25n

* CHECK dout0_8 Vdout0_8ck198 = 1.8 time = 9950
.meas tran vdout0_8ck198 FIND v(dout0_8) AT=9950.25n

* CHECK dout0_9 Vdout0_9ck198 = 1.8 time = 9950
.meas tran vdout0_9ck198 FIND v(dout0_9) AT=9950.25n

* CHECK dout0_10 Vdout0_10ck198 = 0 time = 9950
.meas tran vdout0_10ck198 FIND v(dout0_10) AT=9950.25n

* CHECK dout0_11 Vdout0_11ck198 = 0 time = 9950
.meas tran vdout0_11ck198 FIND v(dout0_11) AT=9950.25n

* CHECK dout0_12 Vdout0_12ck198 = 0 time = 9950
.meas tran vdout0_12ck198 FIND v(dout0_12) AT=9950.25n

* CHECK dout0_13 Vdout0_13ck198 = 1.8 time = 9950
.meas tran vdout0_13ck198 FIND v(dout0_13) AT=9950.25n

* CHECK dout0_14 Vdout0_14ck198 = 1.8 time = 9950
.meas tran vdout0_14ck198 FIND v(dout0_14) AT=9950.25n

* CHECK dout0_15 Vdout0_15ck198 = 1.8 time = 9950
.meas tran vdout0_15ck198 FIND v(dout0_15) AT=9950.25n

* CHECK dout0_0 Vdout0_0ck199 = 0 time = 10000
.meas tran vdout0_0ck199 FIND v(dout0_0) AT=10000.25n

* CHECK dout0_1 Vdout0_1ck199 = 1.8 time = 10000
.meas tran vdout0_1ck199 FIND v(dout0_1) AT=10000.25n

* CHECK dout0_2 Vdout0_2ck199 = 0 time = 10000
.meas tran vdout0_2ck199 FIND v(dout0_2) AT=10000.25n

* CHECK dout0_3 Vdout0_3ck199 = 0 time = 10000
.meas tran vdout0_3ck199 FIND v(dout0_3) AT=10000.25n

* CHECK dout0_4 Vdout0_4ck199 = 1.8 time = 10000
.meas tran vdout0_4ck199 FIND v(dout0_4) AT=10000.25n

* CHECK dout0_5 Vdout0_5ck199 = 0 time = 10000
.meas tran vdout0_5ck199 FIND v(dout0_5) AT=10000.25n

* CHECK dout0_6 Vdout0_6ck199 = 1.8 time = 10000
.meas tran vdout0_6ck199 FIND v(dout0_6) AT=10000.25n

* CHECK dout0_7 Vdout0_7ck199 = 0 time = 10000
.meas tran vdout0_7ck199 FIND v(dout0_7) AT=10000.25n

* CHECK dout0_8 Vdout0_8ck199 = 0 time = 10000
.meas tran vdout0_8ck199 FIND v(dout0_8) AT=10000.25n

* CHECK dout0_9 Vdout0_9ck199 = 1.8 time = 10000
.meas tran vdout0_9ck199 FIND v(dout0_9) AT=10000.25n

* CHECK dout0_10 Vdout0_10ck199 = 0 time = 10000
.meas tran vdout0_10ck199 FIND v(dout0_10) AT=10000.25n

* CHECK dout0_11 Vdout0_11ck199 = 1.8 time = 10000
.meas tran vdout0_11ck199 FIND v(dout0_11) AT=10000.25n

* CHECK dout0_12 Vdout0_12ck199 = 0 time = 10000
.meas tran vdout0_12ck199 FIND v(dout0_12) AT=10000.25n

* CHECK dout0_13 Vdout0_13ck199 = 1.8 time = 10000
.meas tran vdout0_13ck199 FIND v(dout0_13) AT=10000.25n

* CHECK dout0_14 Vdout0_14ck199 = 0 time = 10000
.meas tran vdout0_14ck199 FIND v(dout0_14) AT=10000.25n

* CHECK dout0_15 Vdout0_15ck199 = 1.8 time = 10000
.meas tran vdout0_15ck199 FIND v(dout0_15) AT=10000.25n

* CHECK dout0_0 Vdout0_0ck201 = 1.8 time = 10100
.meas tran vdout0_0ck201 FIND v(dout0_0) AT=10100.25n

* CHECK dout0_1 Vdout0_1ck201 = 1.8 time = 10100
.meas tran vdout0_1ck201 FIND v(dout0_1) AT=10100.25n

* CHECK dout0_2 Vdout0_2ck201 = 0 time = 10100
.meas tran vdout0_2ck201 FIND v(dout0_2) AT=10100.25n

* CHECK dout0_3 Vdout0_3ck201 = 1.8 time = 10100
.meas tran vdout0_3ck201 FIND v(dout0_3) AT=10100.25n

* CHECK dout0_4 Vdout0_4ck201 = 0 time = 10100
.meas tran vdout0_4ck201 FIND v(dout0_4) AT=10100.25n

* CHECK dout0_5 Vdout0_5ck201 = 1.8 time = 10100
.meas tran vdout0_5ck201 FIND v(dout0_5) AT=10100.25n

* CHECK dout0_6 Vdout0_6ck201 = 0 time = 10100
.meas tran vdout0_6ck201 FIND v(dout0_6) AT=10100.25n

* CHECK dout0_7 Vdout0_7ck201 = 1.8 time = 10100
.meas tran vdout0_7ck201 FIND v(dout0_7) AT=10100.25n

* CHECK dout0_8 Vdout0_8ck201 = 0 time = 10100
.meas tran vdout0_8ck201 FIND v(dout0_8) AT=10100.25n

* CHECK dout0_9 Vdout0_9ck201 = 1.8 time = 10100
.meas tran vdout0_9ck201 FIND v(dout0_9) AT=10100.25n

* CHECK dout0_10 Vdout0_10ck201 = 0 time = 10100
.meas tran vdout0_10ck201 FIND v(dout0_10) AT=10100.25n

* CHECK dout0_11 Vdout0_11ck201 = 0 time = 10100
.meas tran vdout0_11ck201 FIND v(dout0_11) AT=10100.25n

* CHECK dout0_12 Vdout0_12ck201 = 1.8 time = 10100
.meas tran vdout0_12ck201 FIND v(dout0_12) AT=10100.25n

* CHECK dout0_13 Vdout0_13ck201 = 1.8 time = 10100
.meas tran vdout0_13ck201 FIND v(dout0_13) AT=10100.25n

* CHECK dout0_14 Vdout0_14ck201 = 1.8 time = 10100
.meas tran vdout0_14ck201 FIND v(dout0_14) AT=10100.25n

* CHECK dout0_15 Vdout0_15ck201 = 0 time = 10100
.meas tran vdout0_15ck201 FIND v(dout0_15) AT=10100.25n

* CHECK dout0_0 Vdout0_0ck202 = 1.8 time = 10150
.meas tran vdout0_0ck202 FIND v(dout0_0) AT=10150.25n

* CHECK dout0_1 Vdout0_1ck202 = 0 time = 10150
.meas tran vdout0_1ck202 FIND v(dout0_1) AT=10150.25n

* CHECK dout0_2 Vdout0_2ck202 = 1.8 time = 10150
.meas tran vdout0_2ck202 FIND v(dout0_2) AT=10150.25n

* CHECK dout0_3 Vdout0_3ck202 = 0 time = 10150
.meas tran vdout0_3ck202 FIND v(dout0_3) AT=10150.25n

* CHECK dout0_4 Vdout0_4ck202 = 0 time = 10150
.meas tran vdout0_4ck202 FIND v(dout0_4) AT=10150.25n

* CHECK dout0_5 Vdout0_5ck202 = 1.8 time = 10150
.meas tran vdout0_5ck202 FIND v(dout0_5) AT=10150.25n

* CHECK dout0_6 Vdout0_6ck202 = 1.8 time = 10150
.meas tran vdout0_6ck202 FIND v(dout0_6) AT=10150.25n

* CHECK dout0_7 Vdout0_7ck202 = 1.8 time = 10150
.meas tran vdout0_7ck202 FIND v(dout0_7) AT=10150.25n

* CHECK dout0_8 Vdout0_8ck202 = 1.8 time = 10150
.meas tran vdout0_8ck202 FIND v(dout0_8) AT=10150.25n

* CHECK dout0_9 Vdout0_9ck202 = 1.8 time = 10150
.meas tran vdout0_9ck202 FIND v(dout0_9) AT=10150.25n

* CHECK dout0_10 Vdout0_10ck202 = 1.8 time = 10150
.meas tran vdout0_10ck202 FIND v(dout0_10) AT=10150.25n

* CHECK dout0_11 Vdout0_11ck202 = 1.8 time = 10150
.meas tran vdout0_11ck202 FIND v(dout0_11) AT=10150.25n

* CHECK dout0_12 Vdout0_12ck202 = 0 time = 10150
.meas tran vdout0_12ck202 FIND v(dout0_12) AT=10150.25n

* CHECK dout0_13 Vdout0_13ck202 = 1.8 time = 10150
.meas tran vdout0_13ck202 FIND v(dout0_13) AT=10150.25n

* CHECK dout0_14 Vdout0_14ck202 = 0 time = 10150
.meas tran vdout0_14ck202 FIND v(dout0_14) AT=10150.25n

* CHECK dout0_15 Vdout0_15ck202 = 0 time = 10150
.meas tran vdout0_15ck202 FIND v(dout0_15) AT=10150.25n

* probe is used for hspice/xa, while plot is used in ngspice
*.probe V(*)
*.plot V(*)
.end
